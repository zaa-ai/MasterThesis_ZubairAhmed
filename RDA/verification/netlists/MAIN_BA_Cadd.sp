cg21695_78 xdut.xana.xdsi_ch1<1>.vshunt_h 0 c=7.81192e-13
c21695_68 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.xdsi_ch1<1>.xtx.vbp5v_12v c=2.24369e-13
c21695_64 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.xdsi_ch1<1>.xtx.i_dac_5v c=1.63099e-14
c21695_63 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.xdsi_ch1<0>.xtx.vcc_nbl c=1.04819e-14
c21695_61 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_99 c=1.45162e-15
c21695_60 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_96 c=1.82584e-15
c21695_57 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_93 c=1.53673e-15
c21695_55 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_91 c=1.60929e-15
c21695_54 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_90 c=1.45634e-15
c21695_51 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_88 c=1.98845e-15
c21695_48 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_85 c=1.53603e-15
c21695_46 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_83 c=1.45699e-15
c21695_44 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_81 c=1.45627e-15
c21695_43 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_77 c=1.82599e-15
c21695_40 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_74 c=1.44597e-15
c21695_38 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_72 c=1.45682e-15
c21695_35 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_65 c=1.95494e-15
c21695_34 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_64 c=1.34206e-15
c21695_28 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_24 c=3.58009e-15
c21695_27 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_23 c=1.86788e-15
c21695_26 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_22 c=2.29847e-15
c21695_22 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_101 c=1.60731e-15
c21695_18 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.xdsi_ch1<1>.xrx.vhs_sup c=2.8706e-13
c21695_17 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.xdsi_ch1<1>.xrx.inp_iq_s c=1.51778e-15
c21695_16 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.xdsi_ch1<1>.xrx.inp_iq c=6.73455e-15
c21695_15 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.xdsi_ch1<1>.xrx.inp_dat2_cmp c=2.76743e-15
c21695_14 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.xdsi_ch1<1>.xrx.inp_dat1_cmp c=2.29468e-15
c21695_13 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.xdsi_ch1<1>.xrx.inn_iq c=2.56798e-15
c21695_12 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.xdsi_ch1<1>.xrx.inn_dat2_cmp c=2.63623e-15
c21695_11 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.xdsi_ch1<1>.xrx.inn_dat1_cmp c=1.66103e-15
c21695_4 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd c=2.64654e-15
c21695_3 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.gnd_dsi c=8.70997e-13
c21695_2 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.dsi1_p c=6.09521e-13
c21695_1 xdut.xana.xdsi_ch1<1>.vshunt_h xdut.xana.xdsi_ch1<1>.vsup_dsi c=2.31946e-13
c21689_2 xdut.xana.xdsi_ch1<1>.xrx.xdat1_cmp.n4 xdut.gnd_dsi c=5.46802e-15
c21688_2 xdut.xana.xdsi_ch1<1>.xrx.xdat1_cmp.n3 xdut.gnd_dsi c=1.18637e-14
cg21682_47 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vpnc2 0 c=2.2736e-14
c21682_5 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vpnc2 xdut.aout_int c=1.47772e-15
c21682_4 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vpnc2 xdut.gnd_dsi c=1.10487e-13
cg21681_17 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vpnc1 0 c=7.90106e-15
c21681_2 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vpnc1 xdut.gnd_dsi c=6.55684e-14
cg21680_42 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vbn5v_12v 0 c=1.18067e-12
c648109_10 xdut.xpad18.oeb xdut.xpad18.oebb c=1.76591e-15
c648109_4 xdut.xpad18.oeb xdut.gndd_p c=2.21881e-15
c648108_14 xdut.xpad18.oebb xdut.xpad18.ib c=1.02614e-15
c648108_4 xdut.xpad18.oebb xdut.gndd_p c=1.08238e-15
c648104_4 xdut.xpad18.i2 xdut.gndd_p c=2.29869e-15
cg21111_14 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2388 0 c=8.26498e-15
c21111_1 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2388 xdut.gnd_dsi c=3.2212e-14
c21110_2 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net1294 xdut.gnd_dsi c=3.33194e-14
c647844_3 xdut.xpad1.ieb xdut.gndd_p c=2.67437e-15
c647842_4 xdut.xpad1.iebb xdut.gndd_p c=2.31936e-15
cg21099_44 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2530 0 c=1.0586e-13
c21099_3 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2530 xdut.gnd_dsi c=1.08921e-13
c21099_2 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2530 xdut.dsi0_p c=3.67011e-15
c647833_3 xdut.xpad1.gpesd xdut.clkref_p c=1.30936e-14
c647833_1 xdut.xpad1.gpesd xdut.vio_p c=2.7338e-14
c647832_3 xdut.xpad1.gnesd xdut.clkref_p c=3.67815e-14
c647832_2 xdut.xpad1.gnesd xdut.dgnd_p c=8.22525e-14
cg21089_29 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vbnc_5v 0 c=3.32587e-14
c21089_2 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vbnc_5v xdut.gnd_dsi c=5.8478e-14
cg21088_15 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2390 0 c=7.97819e-15
c21088_2 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2390 xdut.gnd_dsi c=4.47197e-14
cg20665_38 xdut.xana.xdsi_ch1<0>.xtx.vbp5v_12v 0 c=4.47846e-14
c20665_17 xdut.xana.xdsi_ch1<0>.xtx.vbp5v_12v xdut.xana.xdsi_ch1<1>.xtx.vcc_nbl c=2.85783e-15
c20665_12 xdut.xana.xdsi_ch1<0>.xtx.vbp5v_12v xdut.xana.xdsi_ch1<0>.vshunt_h c=2.24356e-13
c20665_5 xdut.xana.xdsi_ch1<0>.xtx.vbp5v_12v xdut.gnd_dsi c=1.63282e-13
c20665_4 xdut.xana.xdsi_ch1<0>.xtx.vbp5v_12v xdut.dsi0_p c=4.09021e-15
c20665_3 xdut.xana.xdsi_ch1<0>.xtx.vbp5v_12v xdut.xana.xdsi_ch1<0>.vsup_dsi c=3.98507e-13
cg20633_43 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vnco 0 c=8.21591e-14
c20633_2 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vnco xdut.gnd_dsi c=9.26349e-13
cg20624_128 xdut.xana.xdsi_ch1<0>.xtx.i_dac_5v 0 c=1.66652e-14
c20624_13 xdut.xana.xdsi_ch1<0>.xtx.i_dac_5v xdut.xana.xdsi_ch1<0>.vshunt_h c=1.62806e-14
c20624_9 xdut.xana.xdsi_ch1<0>.xtx.i_dac_5v xdut.xana.cldo_dsi<0> c=2.92863e-13
c20624_6 xdut.xana.xdsi_ch1<0>.xtx.i_dac_5v xdut.aout_int c=1.24882e-14
c20624_5 xdut.xana.xdsi_ch1<0>.xtx.i_dac_5v xdut.gnd_dsi c=5.05593e-12
c20624_4 xdut.xana.xdsi_ch1<0>.xtx.i_dac_5v xdut.dsi0_p c=5.33768e-15
c20624_3 xdut.xana.xdsi_ch1<0>.xtx.i_dac_5v xdut.xana.xdsi_ch1<0>.vsup_dsi c=1.71936e-13
c20573_2 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vnc2 xdut.gnd_dsi c=5.16014e-14
c20572_3 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vngo xdut.aout_int c=2.22077e-15
c20572_2 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vngo xdut.gnd_dsi c=1.79503e-13
cg647232_14 xdut.xosc.xpll_top_0.xpll_core_0.ibias 0 c=3.73184e-15
c647232_3 xdut.xosc.xpll_top_0.xpll_core_0.ibias xdut.gndd_p c=8.66477e-15
c647232_2 xdut.xosc.xpll_top_0.xpll_core_0.ibias xdut.pll_ic5u c=1.09245e-15
cg20483_67 xdut.xana.xdsi_ch1<1>.xtx.vcc_nbl 0 c=4.17648e-14
c20483_28 xdut.xana.xdsi_ch1<1>.xtx.vcc_nbl xdut.xana.xdsi_ch1<0>.xtx.rx_txn_5v c=1.02359e-15
c20483_16 xdut.xana.xdsi_ch1<1>.xtx.vcc_nbl xdut.xana.xdsi_ch1<0>.net292 c=6.47308e-15
c20483_15 xdut.xana.xdsi_ch1<1>.xtx.vcc_nbl xdut.xana.xdsi_ch1<0>.vshunt_h c=1.01027e-14
c20483_9 xdut.xana.xdsi_ch1<1>.xtx.vcc_nbl xdut.xana.irp10u<0> c=2.1642e-15
c20483_8 xdut.xana.xdsi_ch1<1>.xtx.vcc_nbl xdut.xana.ic5u<0> c=3.00419e-15
c20483_6 xdut.xana.xdsi_ch1<1>.xtx.vcc_nbl xdut.aout_int c=3.43315e-15
c20483_5 xdut.xana.xdsi_ch1<1>.xtx.vcc_nbl xdut.gnd_dsi c=7.68017e-13
c20483_3 xdut.xana.xdsi_ch1<1>.xtx.vcc_nbl xdut.xana.xdsi_ch1<0>.vsup_dsi c=3.06179e-15
cg20427_44 xdut.xana.xdsi_ch1<0>.net292 0 c=8.63405e-14
c20427_9 xdut.xana.xdsi_ch1<0>.net292 xdut.xana.cldo_dsi<0> c=5.39168e-15
c20427_7 xdut.xana.xdsi_ch1<0>.net292 xdut.xana.ic5u<0> c=1.36944e-14
c20427_4 xdut.xana.xdsi_ch1<0>.net292 xdut.gnd_dsi c=1.65639e-14
c20427_3 xdut.xana.xdsi_ch1<0>.net292 xdut.xana.xdsi_ch1<0>.vsup_dsi c=1.45383e-14
c20425_3 xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_99 xdut.xana.xdsi_ch1<0>.vshunt_h c=1.45163e-15
c20425_2 xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_99 xdut.gnd_dsi c=1.85401e-15
c20393_2 xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_26 xdut.gnd_dsi c=1.80745e-15
c20393_1 xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_26 xdut.dsi0_p c=3.67565e-15
c20391_3 xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_23 xdut.xana.xdsi_ch1<0>.vshunt_h c=1.86792e-15
c20391_2 xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_23 xdut.gnd_dsi c=1.81069e-15
c20391_1 xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_23 xdut.dsi0_p c=2.19536e-15
c20385_2 xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_100 xdut.gnd_dsi c=1.85327e-15
c20385_1 xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_100 xdut.dsi0_p c=1.59891e-15
c647091_4 xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.foutb xdut.gndd_p c=1.43268e-15
c647090_4 xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.fouta xdut.gndd_p c=1.77906e-15
c647047_3 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<70>.pullup xdut.gndd_p c=3.94946e-15
cg647031_66 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.ibias_buf<1> 0 c=1.27444e-14
c647031_2 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.ibias_buf<1> xdut.gndd_p c=6.00487e-15
cg647030_45 xdut.xosc.xpll_top_0.xpll_core_0.net825<1> 0 c=1.07029e-14
cg647029_60 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.ibias_buf<0> 0 c=1.07518e-14
c647029_2 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.ibias_buf<0> xdut.gndd_p c=4.24715e-15
cg647028_44 xdut.xosc.xpll_top_0.xpll_core_0.net825<0> 0 c=1.06242e-14
cg647013_87 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.vcascn 0 c=8.52456e-15
c647013_3 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.vcascn xdut.gndd_p c=3.21642e-14
cg647012_62 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net043 0 c=4.1562e-13
c647012_3 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net043 xdut.gndd_p c=3.84971e-15
cg647009_75 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.vbiasn 0 c=8.65597e-15
c647009_2 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.vbiasn xdut.gndd_p c=4.02953e-14
c647008_3 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<5>.pullup xdut.gndd_p c=3.94457e-15
c647007_3 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<6>.pullup xdut.gndd_p c=3.95449e-15
c647005_3 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<4>.pullup xdut.gndd_p c=3.94749e-15
c20216_29 xdut.xana.xdsi_ch1<0>.xrx.xrec_th.pbias2_cs xdut.net6 c=1.11296e-15
c20216_3 xdut.xana.xdsi_ch1<0>.xrx.xrec_th.pbias2_cs xdut.gnd_dsi c=7.0602e-15
cg20212_19 xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim1.on_os_3 0 c=4.11029e-15
c20212_3 xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim1.on_os_3 xdut.gnd_dsi c=3.05483e-15
cg20210_18 xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim2.on_os_3 0 c=4.10249e-15
c20210_3 xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim2.on_os_3 xdut.gnd_dsi c=2.98829e-15
c20204_3 xdut.xana.xdsi_ch1<0>.xrx.xrec_th.pbias1_cs xdut.gnd_dsi c=7.60404e-15
cg646914_45 xdut.xosc.xpll_top_0.itune 0 c=6.10949e-15
c646914_21 xdut.xosc.xpll_top_0.itune xdut.gndd_p c=7.88436e-14
c646914_20 xdut.xosc.xpll_top_0.itune xdut.pll_ic5u c=1.33903e-15
c646914_6 xdut.xosc.xpll_top_0.itune xdut.pll_on c=1.11134e-15
cg646896_71 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.stdbyq 0 c=6.9424e-15
c646896_3 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.stdbyq xdut.gndd_p c=5.64348e-15
c646896_2 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.stdbyq xdut.pll_ic5u c=1.27559e-15
c20131_4 xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.net898 xdut.gndd_p c=1.75842e-15
c20092_2 xdut.xana.xdsi_ch1<0>.xrx.xhs_sup.nd_mnb2 xdut.gnd_dsi c=3.56294e-15
c20088_3 xdut.xana.xdsi_ch1<0>.xrx.xhs_sup.ndio_lv xdut.gnd_dsi c=1.94453e-14
cg20087_15 xdut.xana.xdsi_ch1<0>.xrx.xhs_sup.mn_hv_lim_d 0 c=3.82226e-15
c20087_3 xdut.xana.xdsi_ch1<0>.xrx.xhs_sup.mn_hv_lim_d xdut.gnd_dsi c=9.94054e-15
c646821_3 xdut.xosc.xosc_20m_0.xosc20m_0.xring.cout2 xdut.gndd_p c=1.03206e-15
c646820_2 xdut.xosc.xosc_20m_0.xosc20m_0.xring.cb<4> xdut.gndd_p c=1.77458e-15
c646819_2 xdut.xosc.xosc_20m_0.xosc20m_0.xring.cb<3> xdut.gndd_p c=1.76545e-15
c646817_2 xdut.xosc.xosc_20m_0.xosc20m_0.xring.cb<2> xdut.gndd_p c=1.73367e-15
c646816_2 xdut.xosc.xosc_20m_0.xosc20m_0.xring.cb<1> xdut.gndd_p c=2.40409e-15
c646815_3 xdut.xosc.xosc_20m_0.xosc20m_0.xring.cb<5> xdut.gndd_p c=4.26054e-15
c646810_1 xdut.xosc.xosc_20m_0.xosc20m_0.xring.dp2_gnd xdut.gndd_p c=1.51131e-15
c646809_2 xdut.xosc.xosc_20m_0.xosc20m_0.xring.cout1 xdut.gndd_p c=1.32126e-15
c646808_1 xdut.xosc.xosc_20m_0.xosc20m_0.xring.dp1_gnd xdut.gndd_p c=1.76628e-15
c646807_3 xdut.xosc.xosc_20m_0.xosc20m_0.xring.c<5> xdut.gndd_p c=3.7137e-15
c646804_2 xdut.xosc.xosc_20m_0.xosc20m_0.xring.c<4> xdut.gndd_p c=3.02845e-15
c646801_2 xdut.xosc.xosc_20m_0.xosc20m_0.xring.c<3> xdut.gndd_p c=3.08917e-15
c646798_1 xdut.xosc.xosc_20m_0.xosc20m_0.xring.c<2> xdut.gndd_p c=3.0243e-15
c646792_2 xdut.xosc.xosc_20m_0.xosc20m_0.xring.c<1> xdut.gndd_p c=3.07118e-15
c646790_3 xdut.xosc.xosc_20m_0.xosc20m_0.xring.foutb xdut.gndd_p c=1.40385e-15
cg20016_6 xdut.xana.xdsi_ch1<0>.xrx.xhs_sup.nd_mncas 0 c=1.43702e-15
c20016_2 xdut.xana.xdsi_ch1<0>.xrx.xhs_sup.nd_mncas xdut.gnd_dsi c=1.28187e-15
cg44536_65 xdut.xana.xtmon.ena 0 c=8.80554e-15
c44536_45 xdut.xana.xtmon.ena xdut.xana.xtmon.ot_5v c=1.07706e-15
c44536_40 xdut.xana.xtmon.ena xdut.xana.xtmon.net699 c=4.44996e-15
c44536_13 xdut.xana.xtmon.ena xdut.xana.vdd_uv_5v c=2.57848e-15
c44536_12 xdut.xana.xtmon.ena xdut.aout_int c=3.08349e-15
c44536_3 xdut.xana.xtmon.ena xdut.gnd_p c=2.02641e-15
c44536_2 xdut.xana.xtmon.ena xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.09035e-14
cg44527_4 xdut.xana.xtmon.xtsens.net16 0 c=1.83673e-14
c44527_3 xdut.xana.xtmon.xtsens.net16 xdut.xana.xtmon.xtsens.net21 c=2.44122e-14
c44527_2 xdut.xana.xtmon.xtsens.net16 xdut.gnd_dsi c=4.14812e-15
c44527_1 xdut.xana.xtmon.xtsens.net16 xdut.gnd_p c=2.49457e-14
c19918_3 xdut.xana.xdsi_ch1<0>.xrx.xdat2_cmp.n5 xdut.gnd_dsi c=9.63394e-15
c19917_3 xdut.xana.xdsi_ch1<0>.xrx.xdat2_cmp.n6 xdut.gnd_dsi c=9.63891e-15
cg44492_44 xdut.xana.xtmon.ot_5v 0 c=2.11932e-15
c44492_38 xdut.xana.xtmon.ot_5v xdut.xana.xtmon.v_tsens_i c=5.96788e-15
c44492_22 xdut.xana.xtmon.ot_5v xdut.xana.xtmon.xcomp2.net60 c=1.28944e-15
c44492_19 xdut.xana.xtmon.ot_5v xdut.xana.xtmon.net680 c=1.19554e-15
c44492_17 xdut.xana.xtmon.ot_5v xdut.xana.xtmon.net684 c=1.75255e-15
c44492_16 xdut.xana.xtmon.ot_5v xdut.xana.xtmon.xcomp2.enb c=1.47886e-15
c44492_9 xdut.xana.xtmon.ot_5v xdut.ot_error c=1.96087e-15
c44492_5 xdut.xana.xtmon.ot_5v xdut.gnd_dsi c=3.63786e-15
c44492_3 xdut.xana.xtmon.ot_5v xdut.gnd_p c=3.53353e-15
c44492_2 xdut.xana.xtmon.ot_5v xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=2.57229e-15
c646637_4 xdut.xosc.xosc_20m_0.xosc20m_0.xdecoder.sbb<5> xdut.gndd_p c=7.3506e-15
cg44464_25 xdut.xana.xtmon.vcc_nbl 0 c=9.90927e-15
c44464_11 xdut.xana.xtmon.vcc_nbl xdut.aout_int c=1.19483e-15
c44464_10 xdut.xana.xtmon.vcc_nbl xdut.ot_warn c=1.06316e-15
c44464_5 xdut.xana.xtmon.vcc_nbl xdut.gnd_dsi c=4.45485e-14
c44464_4 xdut.xana.xtmon.vcc_nbl xdut.cldo_p c=1.24668e-15
c44464_3 xdut.xana.xtmon.vcc_nbl xdut.gnd_p c=5.34135e-14
cg44463_17 xdut.xana.xtmon.xcomp2.nn6 0 c=1.5628e-15
c44463_10 xdut.xana.xtmon.xcomp2.nn6 xdut.xana.xtmon.xcomp2.nn4 c=2.71617e-15
c44463_9 xdut.xana.xtmon.xcomp2.nn6 xdut.xana.xtmon.xcomp2.nnvc c=1.61737e-15
c44463_7 xdut.xana.xtmon.xcomp2.nn6 xdut.xana.xtmon.xcomp2.net60 c=1.91547e-15
c44463_4 xdut.xana.xtmon.xcomp2.nn6 xdut.xana.xtmon.net684 c=1.00104e-15
c44463_2 xdut.xana.xtmon.xcomp2.nn6 xdut.gnd_p c=5.68412e-15
cg44459_24 xdut.xana.xtmon.xcomp2.nnvc 0 c=4.9025e-14
c44459_2 xdut.xana.xtmon.xcomp2.nnvc xdut.gnd_p c=3.48877e-14
c44459_1 xdut.xana.xtmon.xcomp2.nnvc xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=2.53486e-15
cg44457_9 xdut.xana.xtmon.xcomp2.net60 0 c=1.12629e-15
c44457_3 xdut.xana.xtmon.xcomp2.net60 xdut.xana.xtmon.net684 c=1.44606e-15
c44457_1 xdut.xana.xtmon.xcomp2.net60 xdut.gnd_p c=2.35864e-15
c19873_2 xdut.xana.ln_dsi_ch1<0>.rx.dat1_cmp.n_367 xdut.gnd_dsi c=1.10796e-15
c44441_2 xdut.xana.xtmon.net684 xdut.gnd_p c=1.14774e-15
c44441_1 xdut.xana.xtmon.net684 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.04066e-15
c44440_6 xdut.xana.xtmon.xcomp2.enb xdut.xana.xtmon.xcomp2.nn4 c=3.33084e-15
c44440_2 xdut.xana.xtmon.xcomp2.enb xdut.gnd_p c=1.88545e-15
c44440_1 xdut.xana.xtmon.xcomp2.enb xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=3.0249e-15
c19857_3 xdut.xana.xdsi_ch1<0>.xrx.xdat1_cmp.n5 xdut.gnd_dsi c=9.69248e-15
c19856_3 xdut.xana.xdsi_ch1<0>.xrx.xdat1_cmp.n6 xdut.gnd_dsi c=9.68921e-15
cg19854_18 xdut.xana.xdsi_ch1<0>.xrx.xdat1_cmp.net462 0 c=1.40814e-15
c19854_2 xdut.xana.xdsi_ch1<0>.xrx.xdat1_cmp.net462 xdut.gnd_dsi c=1.45979e-15
c19844_32 xdut.xana.xdsi_ch1<0>.xrx.rxd2_5v xdut.xana.xdsi_ch1<0>.xrx.rxd1_5v c=3.0129e-14
c19844_31 xdut.xana.xdsi_ch1<0>.xrx.rxd2_5v xdut.xana.xdsi_ch1<0>.xrx.iq_cmp_5v c=1.33423e-15
c19844_28 xdut.xana.xdsi_ch1<0>.xrx.rxd2_5v xdut.xana.xdsi_ch1<0>.xrx.mask_dcmp c=9.96194e-15
c19844_19 xdut.xana.xdsi_ch1<0>.xrx.rxd2_5v xdut.xana.xdsi_ch1<0>.xrx.inp_iq c=1.16783e-15
c19844_4 xdut.xana.xdsi_ch1<0>.xrx.rxd2_5v xdut.gnd_dsi c=1.58671e-14
c19843_34 xdut.xana.xdsi_ch1<0>.xrx.rxd1_5v xdut.xana.xdsi_ch1<0>.xrx.iq_cmp_5v c=1.80672e-14
c19843_31 xdut.xana.xdsi_ch1<0>.xrx.rxd1_5v xdut.xana.xdsi_ch1<0>.xrx.mask_dcmp c=1.11747e-14
c19843_21 xdut.xana.xdsi_ch1<0>.xrx.rxd1_5v xdut.xana.xdsi_ch1<0>.xrx.inp_iq_s c=1.05858e-15
c19843_4 xdut.xana.xdsi_ch1<0>.xrx.rxd1_5v xdut.gnd_dsi c=1.66205e-14
c19843_3 xdut.xana.xdsi_ch1<0>.xrx.rxd1_5v xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd c=1.40332e-15
cg646579_18 xdut.xosc.xosc_20m_0.xosc20m_0.gain 0 c=7.14989e-15
c646579_5 xdut.xosc.xosc_20m_0.xosc20m_0.gain xdut.xosc.xosc_20m_0.xosc20m_0.onb c=1.62975e-15
c646579_4 xdut.xosc.xosc_20m_0.xosc20m_0.gain xdut.gndd_p c=1.30969e-14
c19839_15 xdut.xana.xdsi_ch1<0>.xrx.mask_dcmp xdut.xana.xdsi_ch1<0>.xrx.on_5v c=3.41617e-14
c19839_3 xdut.xana.xdsi_ch1<0>.xrx.mask_dcmp xdut.gnd_dsi c=1.62287e-14
c19839_2 xdut.xana.xdsi_ch1<0>.xrx.mask_dcmp xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd c=6.96487e-15
c19782_3 xdut.xana.xdsi_ch1<0>.xrx.xrec_th.noffset_bias2 xdut.gnd_dsi c=1.32555e-15
c19779_10 xdut.xana.xdsi_ch1<0>.xrx.inn_d2cmp xdut.xana.xdsi_ch1<0>.xrx.vhs_sup c=6.94667e-15
c19779_3 xdut.xana.xdsi_ch1<0>.xrx.inn_d2cmp xdut.gnd_dsi c=8.88064e-15
c19779_2 xdut.xana.xdsi_ch1<0>.xrx.inn_d2cmp xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd c=1.19444e-13
c19771_3 xdut.xana.xdsi_ch1<0>.xrx.xrec_th.bias_idac xdut.gnd_dsi c=1.10572e-13
c19770_3 xdut.xana.xdsi_ch1<0>.xrx.xrec_th.idac_bias2 xdut.gnd_dsi c=2.22909e-15
c19769_3 xdut.xana.xdsi_ch1<0>.xrx.xrec_th.idac_bias1 xdut.gnd_dsi c=3.2924e-15
c19768_3 xdut.xana.xdsi_ch1<0>.xrx.xrec_th.bias_idac_cas xdut.gnd_dsi c=2.15843e-14
c19767_9 xdut.xana.xdsi_ch1<0>.xrx.inp_d2cmp xdut.xana.xdsi_ch1<0>.xrx.vhs_sup c=1.18907e-14
c19767_2 xdut.xana.xdsi_ch1<0>.xrx.inp_d2cmp xdut.gnd_dsi c=1.17897e-14
c19767_1 xdut.xana.xdsi_ch1<0>.xrx.inp_d2cmp xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd c=1.13071e-13
c19766_11 xdut.xana.xdsi_ch1<0>.xrx.inn_d1cmp xdut.xana.xdsi_ch1<0>.xrx.vhs_sup c=6.04165e-15
c19766_3 xdut.xana.xdsi_ch1<0>.xrx.inn_d1cmp xdut.gnd_dsi c=8.9642e-15
c19766_2 xdut.xana.xdsi_ch1<0>.xrx.inn_d1cmp xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd c=1.1313e-13
c19765_9 xdut.xana.xdsi_ch1<0>.xrx.inp_d1cmp xdut.xana.xdsi_ch1<0>.xrx.vhs_sup c=8.11268e-15
c19765_2 xdut.xana.xdsi_ch1<0>.xrx.inp_d1cmp xdut.gnd_dsi c=1.09175e-14
c19765_1 xdut.xana.xdsi_ch1<0>.xrx.inp_d1cmp xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd c=1.09022e-13
c19764_2 xdut.xana.xdsi_ch1<0>.xrx.flt_fast_hs_b xdut.gnd_dsi c=3.54968e-15
c19760_3 xdut.xana.xdsi_ch1<0>.xrx.xdat2_cmp.n2 xdut.gnd_dsi c=3.11052e-15
cg19759_69 xdut.xana.xdsi_ch1<0>.xrx.on_5v 0 c=1.40705e-15
c19759_19 xdut.xana.xdsi_ch1<0>.xrx.on_5v xdut.xana.xdsi_ch1<0>.xrx.vhs_sup c=3.05573e-15
c19759_18 xdut.xana.xdsi_ch1<0>.xrx.on_5v xdut.xana.xdsi_ch1<0>.xrx.flt_fast_5v c=2.50615e-15
c19759_17 xdut.xana.xdsi_ch1<0>.xrx.on_5v xdut.xana.xdsi_ch1<0>.xrx.inp_iq_s c=1.28768e-15
c19759_3 xdut.xana.xdsi_ch1<0>.xrx.on_5v xdut.gnd_dsi c=5.54619e-14
c19759_2 xdut.xana.xdsi_ch1<0>.xrx.on_5v xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd c=1.61484e-14
c646494_4 xdut.xosc.xosc_20m_0.xosc20m_0.xdecoder.sb<5> xdut.gndd_p c=7.55222e-15
c19749_3 xdut.xana.xdsi_ch1<0>.xrx.xdat2_cmp.n1 xdut.gnd_dsi c=3.0498e-15
c646477_4 xdut.xosc.xosc_20m_0.xosc20m_0.xdecoder.sbb<3> xdut.gndd_p c=6.98123e-15
c19737_3 xdut.xana.xdsi_ch1<0>.xrx.xdat1_cmp.n2 xdut.gnd_dsi c=3.11064e-15
c19725_3 xdut.xana.xdsi_ch1<0>.xrx.xdat1_cmp.n1 xdut.gnd_dsi c=3.04544e-15
cg19719_241 xdut.xana.xdsi_ch1<0>.xrx.vhs_sup 0 c=2.66469e-14
c19719_71 xdut.xana.xdsi_ch1<0>.xrx.vhs_sup xdut.xana.xdsi_ch1<0>.xrx.inp_iqcmp c=8.13656e-15
c19719_70 xdut.xana.xdsi_ch1<0>.xrx.vhs_sup xdut.xana.xdsi_ch1<0>.xrx.net899 c=4.93872e-15
c19719_64 xdut.xana.xdsi_ch1<0>.xrx.vhs_sup xdut.xana.xdsi_ch1<0>.xrx.inn_iqcmp c=1.1087e-14
c19719_47 xdut.xana.xdsi_ch1<0>.xrx.vhs_sup xdut.xana.xdsi_ch1<0>.xrx.inp_iq_s c=6.72611e-15
c19719_46 xdut.xana.xdsi_ch1<0>.xrx.vhs_sup xdut.xana.xdsi_ch1<0>.xrx.inp_iq c=5.54669e-15
c19719_43 xdut.xana.xdsi_ch1<0>.xrx.vhs_sup xdut.xana.xdsi_ch1<0>.xrx.inn_iq c=6.99916e-15
c19719_40 xdut.xana.xdsi_ch1<0>.xrx.vhs_sup xdut.xana.xdsi_ch1<0>.xrx.idac_5v<4> c=2.77993e-15
c19719_39 xdut.xana.xdsi_ch1<0>.xrx.vhs_sup xdut.xana.xdsi_ch1<0>.xrx.idac_5v<3> c=1.88216e-15
c19719_37 xdut.xana.xdsi_ch1<0>.xrx.vhs_sup xdut.xana.xdsi_ch1<0>.vshunt_h c=2.87059e-13
c19719_25 xdut.xana.xdsi_ch1<0>.xrx.vhs_sup xdut.xana.tielo c=1.26578e-15
c19719_23 xdut.xana.xdsi_ch1<0>.xrx.vhs_sup xdut.gndd_p c=1.30698e-13
c19719_8 xdut.xana.xdsi_ch1<0>.xrx.vhs_sup xdut.aout_int c=1.18957e-15
c19719_6 xdut.xana.xdsi_ch1<0>.xrx.vhs_sup xdut.gnd_dsi c=1.295e-12
c19719_4 xdut.xana.xdsi_ch1<0>.xrx.vhs_sup xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd c=2.54067e-12
c19719_3 xdut.xana.xdsi_ch1<0>.xrx.vhs_sup xdut.gnd_p c=5.37165e-15
c19698_3 xdut.xana.xdsi_ch1<0>.xrx.net880 xdut.dsi_icmp<0> c=1.00294e-15
c19687_17 xdut.xana.xdsi_ch1<0>.xrx.inp_iq_s xdut.xana.xdsi_ch1<0>.xrx.inp_iqcmp c=1.33576e-14
c19687_14 xdut.xana.xdsi_ch1<0>.xrx.inp_iq_s xdut.xana.xdsi_ch1<0>.xrx.inp_iq c=7.19965e-14
c19687_11 xdut.xana.xdsi_ch1<0>.xrx.inp_iq_s xdut.xana.xdsi_ch1<0>.xrx.inn_iq c=5.2667e-15
c19687_7 xdut.xana.xdsi_ch1<0>.xrx.inp_iq_s xdut.xana.xdsi_ch1<0>.vshunt_h c=1.5024e-15
c19687_6 xdut.xana.xdsi_ch1<0>.xrx.inp_iq_s xdut.gndd_p c=4.9744e-15
c19687_4 xdut.xana.xdsi_ch1<0>.xrx.inp_iq_s xdut.gnd_dsi c=3.90894e-14
c19687_3 xdut.xana.xdsi_ch1<0>.xrx.inp_iq_s xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd c=1.05989e-14
cg19680_35 xdut.xana.xdsi_ch1<0>.xrx.inp_iq 0 c=1.4251e-14
c19680_33 xdut.xana.xdsi_ch1<0>.xrx.inp_iq xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_74 c=1.37999e-15
c19680_21 xdut.xana.xdsi_ch1<0>.xrx.inp_iq xdut.xana.xdsi_ch1<0>.xrx.inp_iqcmp c=2.44847e-15
c19680_19 xdut.xana.xdsi_ch1<0>.xrx.inp_iq xdut.xana.xdsi_ch1<0>.xrx.inn_iqcmp c=1.87221e-15
c19680_16 xdut.xana.xdsi_ch1<0>.xrx.inp_iq xdut.xana.xdsi_ch1<0>.xrx.inn_iq c=7.23092e-14
c19680_10 xdut.xana.xdsi_ch1<0>.xrx.inp_iq xdut.xana.xdsi_ch1<0>.vshunt_h c=6.73456e-15
c19680_9 xdut.xana.xdsi_ch1<0>.xrx.inp_iq xdut.gndd_p c=5.07381e-15
c19680_5 xdut.xana.xdsi_ch1<0>.xrx.inp_iq xdut.gnd_dsi c=3.76479e-14
c19680_3 xdut.xana.xdsi_ch1<0>.xrx.inp_iq xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd c=2.5272e-15
cg19679_34 xdut.xana.xdsi_ch1<0>.xrx.inp_dat2_cmp 0 c=2.78941e-14
c19679_10 xdut.xana.xdsi_ch1<0>.xrx.inp_dat2_cmp xdut.xana.xdsi_ch1<0>.vshunt_h c=2.76744e-15
c19679_4 xdut.xana.xdsi_ch1<0>.xrx.inp_dat2_cmp xdut.gnd_dsi c=6.92462e-14
c19679_3 xdut.xana.xdsi_ch1<0>.xrx.inp_dat2_cmp xdut.dsi0_p c=1.63604e-15
cg19678_28 xdut.xana.xdsi_ch1<0>.xrx.inp_dat1_cmp 0 c=2.29406e-14
c19678_10 xdut.xana.xdsi_ch1<0>.xrx.inp_dat1_cmp xdut.xana.xdsi_ch1<0>.vshunt_h c=2.29454e-15
c19678_6 xdut.xana.xdsi_ch1<0>.xrx.inp_dat1_cmp xdut.xana.ic5u<4> c=1.23e-15
c19678_4 xdut.xana.xdsi_ch1<0>.xrx.inp_dat1_cmp xdut.gnd_dsi c=8.7306e-14
c19678_3 xdut.xana.xdsi_ch1<0>.xrx.inp_dat1_cmp xdut.dsi0_p c=3.28552e-15
cg19677_28 xdut.xana.xdsi_ch1<0>.xrx.inn_iq 0 c=6.82e-15
c19677_25 xdut.xana.xdsi_ch1<0>.xrx.inn_iq xdut.xana.xdsi_ch1<0>.xrx.xflt3.net6 c=4.5222e-15
c19677_22 xdut.xana.xdsi_ch1<0>.xrx.inn_iq xdut.xana.xdsi_ch1<0>.xrx.iq_cmp_5v c=2.68224e-15
c19677_16 xdut.xana.xdsi_ch1<0>.xrx.inn_iq xdut.xana.xdsi_ch1<0>.xrx.idac_5v<4> c=8.84076e-15
c19677_13 xdut.xana.xdsi_ch1<0>.xrx.inn_iq xdut.xana.xdsi_ch1<0>.vshunt_h c=2.57603e-15
c19677_11 xdut.xana.xdsi_ch1<0>.xrx.inn_iq xdut.xana.tielo c=1.37217e-15
c19677_10 xdut.xana.xdsi_ch1<0>.xrx.inn_iq xdut.gndd_p c=1.34998e-14
c19677_9 xdut.xana.xdsi_ch1<0>.xrx.inn_iq xdut.atst_rx<0> c=1.48919e-15
c19677_6 xdut.xana.xdsi_ch1<0>.xrx.inn_iq xdut.gnd_dsi c=4.74252e-14
c19677_4 xdut.xana.xdsi_ch1<0>.xrx.inn_iq xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd c=1.57087e-14
c19677_3 xdut.xana.xdsi_ch1<0>.xrx.inn_iq xdut.gnd_p c=2.19479e-15
cg19675_17 xdut.xana.xdsi_ch1<0>.xrx.inn_dat2_cmp 0 c=2.16504e-14
c19675_8 xdut.xana.xdsi_ch1<0>.xrx.inn_dat2_cmp xdut.xana.xdsi_ch1<0>.vshunt_h c=2.63862e-15
c19675_4 xdut.xana.xdsi_ch1<0>.xrx.inn_dat2_cmp xdut.gnd_dsi c=5.5701e-14
c19675_3 xdut.xana.xdsi_ch1<0>.xrx.inn_dat2_cmp xdut.dsi0_p c=1.82815e-15
cg19674_25 xdut.xana.xdsi_ch1<0>.xrx.inn_dat1_cmp 0 c=6.72542e-15
c19674_8 xdut.xana.xdsi_ch1<0>.xrx.inn_dat1_cmp xdut.xana.xdsi_ch1<0>.vshunt_h c=1.663e-15
c19674_4 xdut.xana.xdsi_ch1<0>.xrx.inn_dat1_cmp xdut.gnd_dsi c=5.33316e-14
c19674_3 xdut.xana.xdsi_ch1<0>.xrx.inn_dat1_cmp xdut.dsi0_p c=3.27266e-15
c646406_6 xdut.xosc.xosc_20m_0.xosc20m_0.ready_ana xdut.gndd_p c=8.2024e-14
c646367_5 xdut.xosc.xosc_20m_0.xosc20m_0.xdecoder.sb<3> xdut.gndd_p c=7.36215e-15
c646352_4 xdut.xosc.xosc_20m_0.xosc20m_0.xdecoder.sbb<1> xdut.gndd_p c=6.9511e-15
cg646348_34 xdut.xosc.xosc_20m_0.xosc20m_0.adj2 0 c=4.34327e-15
c646348_9 xdut.xosc.xosc_20m_0.xosc20m_0.adj2 xdut.xosc.xosc_20m_0.xosc20m_0.onb c=2.90707e-15
c646348_7 xdut.xosc.xosc_20m_0.xosc20m_0.adj2 xdut.gndd_p c=1.4978e-14
c646348_4 xdut.xosc.xosc_20m_0.xosc20m_0.adj2 xdut.atst_osc<2> c=4.62014e-15
cg646338_103 xdut.xosc.xosc_20m_0.xosc20m_0.ona 0 c=2.7201e-15
c646338_15 xdut.xosc.xosc_20m_0.xosc20m_0.ona xdut.xosc.xosc_20m_0.aout_osc20m c=5.28625e-15
c646338_14 xdut.xosc.xosc_20m_0.xosc20m_0.ona xdut.xosc.xosc_20m_0.xosc20m_0.onb c=2.26472e-14
c646338_12 xdut.xosc.xosc_20m_0.xosc20m_0.ona xdut.xosc.xosc_20m_0.osc_offa c=1.10234e-14
c646338_11 xdut.xosc.xosc_20m_0.xosc20m_0.ona xdut.gndd_p c=3.94435e-14
c646235_6 xdut.xosc.xosc_20m_0.xosc20m_0.xdecoder.sb<1> xdut.gndd_p c=7.40674e-15
c646110_5 xdut.xosc.xosc_20m_0.xosc20m_0.fout_int xdut.gndd_p c=1.20299e-14
c646110_4 xdut.xosc.xosc_20m_0.xosc20m_0.fout_int xdut.clkosc c=1.26579e-14
c646091_3 xdut.xosc.xosc_20m_0.xosc20m_0.xres.rdiv<127> xdut.gndd_p c=4.11022e-15
cg43801_21 xdut.xana.xsup.xvddreg.nbl1 0 c=2.32834e-14
c43801_15 xdut.xana.xsup.xvddreg.nbl1 xdut.xana.xsup.xvddreg.net153 c=1.27348e-15
c43801_14 xdut.xana.xsup.xvddreg.nbl1 xdut.xana.xsup.ibp5u<3> c=1.6502e-15
c43801_13 xdut.xana.xsup.xvddreg.nbl1 xdut.xana.xsup.ibp5u<2> c=8.2618e-15
c43801_8 xdut.xana.xsup.xvddreg.nbl1 xdut.gndd_p c=5.83425e-14
c43801_3 xdut.xana.xsup.xvddreg.nbl1 xdut.gnd_p c=9.78226e-14
c645909_4 xdut.xosc.xosc_20m_0.xosc20m_0.xdecoder.sbb<0> xdut.gndd_p c=8.59271e-15
c645792_2 xdut.xosc.xosc_20m_0.xosc20m_0.xres.r0 xdut.gndd_p c=2.26646e-14
c645791_5 xdut.xosc.xosc_20m_0.xosc20m_0.xdecoder.sb<0> xdut.gndd_p c=9.45826e-15
c645776_4 xdut.xosc.xosc_20m_0.xosc20m_0.xdecoder.sbb<2> xdut.gndd_p c=6.90891e-15
cg645679_24 xdut.xosc.xosc_20m_0.xosc20m_0.sc 0 c=1.14842e-15
c645679_11 xdut.xosc.xosc_20m_0.xosc20m_0.sc xdut.xosc.xosc_20m_0.xosc20m_0.inp c=1.98606e-15
c645679_5 xdut.xosc.xosc_20m_0.xosc20m_0.sc xdut.gndd_p c=1.17612e-14
c645679_4 xdut.xosc.xosc_20m_0.xosc20m_0.sc xdut.trim_osc_tcf<2> c=1.22863e-15
c645662_4 xdut.xosc.xosc_20m_0.xosc20m_0.res xdut.gndd_p c=9.35756e-15
c645662_3 xdut.xosc.xosc_20m_0.xosc20m_0.res xdut.trim_osc_tcf<2> c=4.69904e-15
c645656_6 xdut.xosc.xosc_20m_0.xosc20m_0.xdecoder.sb<2> xdut.gndd_p c=7.31116e-15
c645626_4 xdut.xosc.xosc_20m_0.xosc20m_0.xdecoder.sbb<4> xdut.gndd_p c=7.05511e-15
c645530_16 xdut.xosc.xosc_20m_0.xosc20m_0.inn xdut.xosc.xosc_20m_0.xosc20m_0.inp c=7.4672e-15
c645530_8 xdut.xosc.xosc_20m_0.xosc20m_0.inn xdut.gndd_p c=1.50363e-14
c645530_2 xdut.xosc.xosc_20m_0.xosc20m_0.inn xdut.trim_osc_tcf<0> c=1.00472e-15
c645517_6 xdut.xosc.xosc_20m_0.xosc20m_0.xdecoder.sb<4> xdut.gndd_p c=7.41551e-15
c645501_7 xdut.xosc.xosc_20m_0.xosc20m_0.xdecoder.sbb<6> xdut.gndd_p c=1.29215e-14
c645439_12 xdut.xosc.xosc_20m_0.fout5m xdut.xosc.xosc_20m_0.fout10m c=1.89725e-14
c645439_11 xdut.xosc.xosc_20m_0.fout5m xdut.xosc.xosc_20m_0.aout_osc20m c=1.39874e-15
c645439_9 xdut.xosc.xosc_20m_0.fout5m xdut.xosc.xosc_20m_0.osc_offa c=1.46656e-15
c645439_8 xdut.xosc.xosc_20m_0.fout5m xdut.gndd_p c=4.90585e-15
c645439_2 xdut.xosc.xosc_20m_0.fout5m xdut.osc_ready c=1.87601e-14
c645438_14 xdut.xosc.xosc_20m_0.fout10m xdut.xosc.xosc_20m_0.xosc20m_0.fout10mb c=1.21184e-15
c645438_7 xdut.xosc.xosc_20m_0.fout10m xdut.xosc.xosc_20m_0.osc_offa c=1.89098e-14
c645438_6 xdut.xosc.xosc_20m_0.fout10m xdut.gndd_p c=4.90552e-15
c645438_2 xdut.xosc.xosc_20m_0.fout10m xdut.osc_ready c=1.432e-15
cg645432_33 xdut.xosc.xosc_20m_0.aout_osc20m 0 c=4.46738e-15
c645432_14 xdut.xosc.xosc_20m_0.aout_osc20m xdut.gndd_p c=1.36318e-14
c645432_12 xdut.xosc.xosc_20m_0.aout_osc20m xdut.atst_osc<0> c=1.55505e-15
c645432_11 xdut.xosc.xosc_20m_0.aout_osc20m xdut.atst_osc<2> c=3.855e-14
c645432_8 xdut.xosc.xosc_20m_0.aout_osc20m xdut.osc_ready c=1.8731e-14
cg645430_38 xdut.xosc.xosc_20m_0.xosc20m_0.onb 0 c=5.21101e-15
c645430_10 xdut.xosc.xosc_20m_0.xosc20m_0.onb xdut.xosc.xosc_20m_0.osc_offa c=1.37561e-15
c645430_9 xdut.xosc.xosc_20m_0.xosc20m_0.onb xdut.gndd_p c=2.93254e-14
c645430_7 xdut.xosc.xosc_20m_0.xosc20m_0.onb xdut.atst_osc<0> c=1.57714e-15
c645430_4 xdut.xosc.xosc_20m_0.xosc20m_0.onb xdut.clkosc c=1.00263e-15
c645426_14 xdut.xosc.xosc_20m_0.osc_offa xdut.xosc.xosc_20m_0.xosc20m_0.net400 c=4.42162e-15
c645426_10 xdut.xosc.xosc_20m_0.osc_offa xdut.gndd_p c=1.14131e-14
c645426_5 xdut.xosc.xosc_20m_0.osc_offa xdut.clkosc c=1.59431e-15
cg645409_15 xdut.xosc.xclkref_lpf_0.rco 0 c=1.12074e-14
c645409_11 xdut.xosc.xclkref_lpf_0.rco xdut.xosc.xclkref_lpf_0.vdd_rc c=1.05494e-15
c645409_4 xdut.xosc.xclkref_lpf_0.rco xdut.gndd_p c=1.1227e-14
c645400_5 xdut.xosc.xosc_20m_0.xatst_single_0.atst_pll_neg xdut.gndd_p c=2.25624e-15
c645400_4 xdut.xosc.xosc_20m_0.xatst_single_0.atst_pll_neg xdut.atst_osc<2> c=1.77707e-15
cg43042_53 xdut.xana.xsup.ibp5u<3> 0 c=1.37566e-14
c43042_51 xdut.xana.xsup.ibp5u<3> xdut.xana.xsup.xvddreg.ibn1u c=1.53143e-15
c43042_49 xdut.xana.xsup.ibp5u<3> xdut.xana.xsup.xref.xbg.vbp_ibias c=1.1942e-15
c43042_44 xdut.xana.xsup.ibp5u<3> xdut.xana.xsup.xref.ibp1u<0> c=1.14652e-15
c43042_37 xdut.xana.xsup.ibp5u<3> xdut.xana.xsup.ibp5u<1> c=1.20496e-15
c43042_36 xdut.xana.xsup.ibp5u<3> xdut.xana.xsup.i_su c=2.74932e-15
c43042_35 xdut.xana.xsup.ibp5u<3> xdut.xana.xsup.ibp5u<2> c=5.99357e-14
c43042_33 xdut.xana.xsup.ibp5u<3> xdut.xana.xsup.ibp10u<2> c=2.16289e-15
c43042_20 xdut.xana.xsup.ibp5u<3> xdut.xana.xsup.vrr_ok_5v c=1.97819e-14
c43042_17 xdut.xana.xsup.ibp5u<3> xdut.xana.vdd_uv_5v c=7.1744e-15
c43042_7 xdut.xana.xsup.ibp5u<3> xdut.gndd_p c=1.15205e-14
c43042_4 xdut.xana.xsup.ibp5u<3> xdut.reg_vdd_dis c=8.98008e-15
c43042_3 xdut.xana.xsup.ibp5u<3> xdut.gnd_p c=3.90225e-14
c43042_2 xdut.xana.xsup.ibp5u<3> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=7.47077e-15
cg43041_38 xdut.xana.xsup.i_su 0 c=1.13738e-14
c43041_36 xdut.xana.xsup.i_su xdut.xana.xsup.xvddreg.xvddreg.gate c=3.27987e-15
c43041_35 xdut.xana.xsup.i_su xdut.xana.xsup.xvddreg.xvddreg.vref_flt c=5.94899e-15
c43041_33 xdut.xana.xsup.i_su xdut.xana.xsup.xvddreg.xvddreg.vfbi c=6.09128e-15
c43041_31 xdut.xana.xsup.i_su xdut.xana.xsup.xvddreg.xvddreg.net377 c=4.69491e-15
c43041_29 xdut.xana.xsup.i_su xdut.xana.xsup.xvddreg.ibn1u c=3.03566e-15
c43041_23 xdut.xana.xsup.i_su xdut.xana.xsup.xvccreg.xreg.startup_int c=5.6472e-15
c43041_21 xdut.xana.xsup.i_su xdut.xana.xsup.xvccreg.rdiv<25> c=2.37108e-14
c43041_19 xdut.xana.xsup.i_su xdut.xana.xsup.vbg c=2.78065e-14
c43041_18 xdut.xana.xsup.i_su xdut.xana.xsup.ibp10u<2> c=7.20931e-14
c43041_16 xdut.xana.xsup.i_su xdut.xana.xsup.vcc_ok_5v c=3.69128e-15
c43041_13 xdut.xana.xsup.i_su xdut.gndd_p c=2.81283e-14
c43041_11 xdut.xana.xsup.i_su xdut.vdd_iload_dis c=1.15711e-15
c43041_10 xdut.xana.xsup.i_su xdut.reg_vdd_dis c=1.08781e-14
c43041_3 xdut.xana.xsup.i_su xdut.gnd_p c=1.01732e-13
c43041_2 xdut.xana.xsup.i_su xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=2.02493e-15
cg43040_56 xdut.xana.xsup.ibp5u<2> 0 c=1.37746e-14
c43040_46 xdut.xana.xsup.ibp5u<2> xdut.xana.xsup.xref.xbg.vbp_ibias c=1.19698e-15
c43040_35 xdut.xana.xsup.ibp5u<2> xdut.xana.xsup.ibp5u<1> c=1.95247e-14
c43040_33 xdut.xana.xsup.ibp5u<2> xdut.xana.xsup.ibp10u<2> c=3.21934e-14
c43040_29 xdut.xana.xsup.ibp5u<2> xdut.xana.xsup.vcc_ok_5v c=7.68072e-14
c43040_27 xdut.xana.xsup.ibp5u<2> xdut.xana.xsup.vcc_nbl c=2.09227e-15
c43040_20 xdut.xana.xsup.ibp5u<2> xdut.xana.xsup.vrr_ok_5v c=1.48342e-15
c43040_16 xdut.xana.xsup.ibp5u<2> xdut.xana.ibp5u<0> c=1.13965e-15
c43040_7 xdut.xana.xsup.ibp5u<2> xdut.gndd_p c=3.96707e-14
c43040_3 xdut.xana.xsup.ibp5u<2> xdut.gnd_p c=2.36741e-14
c43040_2 xdut.xana.xsup.ibp5u<2> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.0174e-14
cg43039_118 xdut.xana.xsup.vbg 0 c=3.47322e-14
c43039_97 xdut.xana.xsup.vbg xdut.xana.xsup.xvddreg.rdiv<28> c=8.87828e-15
c43039_92 xdut.xana.xsup.vbg xdut.xana.xsup.xvddreg.net153 c=2.60851e-15
c43039_88 xdut.xana.xsup.vbg xdut.xana.xsup.xvccreg.xreg.err_amp_base c=2.05121e-15
c43039_83 xdut.xana.xsup.vbg xdut.xana.xsup.xvccreg.xreg.n0 c=3.53307e-15
c43039_75 xdut.xana.xsup.vbg xdut.xana.xsup.xvccreg.rdiv<25> c=4.36653e-15
c43039_73 xdut.xana.xsup.vbg xdut.xana.xsup.xvbgbuf.net213 c=2.13471e-14
c43039_72 xdut.xana.xsup.vbg xdut.xana.xsup.xvbgbuf.vg_m5 c=1.09092e-15
c43039_71 xdut.xana.xsup.vbg xdut.xana.xsup.xvbgbuf.vgpc c=1.98037e-14
c43039_68 xdut.xana.xsup.vbg xdut.xana.xsup.xref.xbg.nwell1 c=4.66968e-15
c43039_64 xdut.xana.xsup.vbg xdut.xana.xsup.xref.xbg.net496 c=2.0147e-15
c43039_63 xdut.xana.xsup.vbg xdut.xana.xsup.xref.xbg.rs_nwell c=6.64045e-15
c43039_51 xdut.xana.xsup.vbg xdut.xana.xsup.ibp5u<1> c=3.25042e-15
c43039_50 xdut.xana.xsup.vbg xdut.xana.xsup.ibp10u<2> c=2.35656e-14
c43039_25 xdut.xana.xsup.vbg xdut.xana.vbg_buf c=1.28209e-14
c43039_18 xdut.xana.xsup.vbg xdut.gndd_p c=2.2181e-14
c43039_11 xdut.xana.xsup.vbg xdut.xana.xsup.xvddreg.xvddreg.v5raw c=2.05654e-15
c43039_8 xdut.xana.xsup.vbg xdut.xana.xsup.xvccreg.xreg.n1_net c=3.35394e-15
c43039_3 xdut.xana.xsup.vbg xdut.gnd_p c=3.37759e-13
c43039_2 xdut.xana.xsup.vbg xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=6.9079e-15
cg43037_65 xdut.xana.xsup.ibp10u<2> 0 c=1.76398e-14
c43037_64 xdut.xana.xsup.ibp10u<2> xdut.xana.xsup.xvccreg.xreg.gate c=5.12873e-15
c43037_56 xdut.xana.xsup.ibp10u<2> xdut.xana.xsup.xvccreg.xreg.n0 c=1.87372e-15
c43037_50 xdut.xana.xsup.ibp10u<2> xdut.xana.xsup.xref.xbg.vbp_ibias c=2.55366e-15
c43037_49 xdut.xana.xsup.ibp10u<2> xdut.xana.xsup.ibp10u<0> c=1.16398e-15
c43037_48 xdut.xana.xsup.ibp10u<2> xdut.xana.xsup.xref.ibp1u<3> c=1.47649e-15
c43037_42 xdut.xana.xsup.ibp10u<2> xdut.xana.xsup.ibp10u<3> c=1.95432e-14
c43037_41 xdut.xana.xsup.ibp10u<2> xdut.xana.xsup.xref.iaux10u c=1.40757e-15
c43037_35 xdut.xana.xsup.ibp10u<2> xdut.xana.xsup.vcc_ok_5v c=6.46281e-14
c43037_34 xdut.xana.xsup.ibp10u<2> xdut.xana.xsup.ibp10u<1> c=1.89591e-14
c43037_14 xdut.xana.xsup.ibp10u<2> xdut.gndd_p c=3.98755e-14
c43037_8 xdut.xana.xsup.ibp10u<2> xdut.xana.xsup.xvccreg.xreg.net830 c=2.51313e-15
c43037_5 xdut.xana.xsup.ibp10u<2> xdut.xana.xsup.xvccreg.xreg.vbat c=4.98012e-15
c43037_3 xdut.xana.xsup.ibp10u<2> xdut.gnd_p c=6.83356e-14
c43037_2 xdut.xana.xsup.ibp10u<2> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=3.03998e-15
cg43023_54 xdut.xana.xsup.vdd_ok_5v 0 c=4.81815e-15
c43023_51 xdut.xana.xsup.vdd_ok_5v xdut.xana.xsup.xvddreg.xcomp.net60 c=1.28778e-15
c43023_50 xdut.xana.xsup.vdd_ok_5v xdut.xana.xsup.xvddreg.xcomp.enb c=1.35086e-15
c43023_45 xdut.xana.xsup.vdd_ok_5v xdut.xana.xsup.xvddreg.vdd_uv_i c=2.81252e-15
c43023_31 xdut.xana.xsup.vdd_ok_5v xdut.xana.xsup.i_trim_5v<3> c=6.82493e-15
c43023_30 xdut.xana.xsup.vdd_ok_5v xdut.xana.xsup.vcc_ok_5v c=9.21795e-15
c43023_18 xdut.xana.xsup.vdd_ok_5v xdut.xana.vdd_uv_5v c=2.11333e-14
c43023_9 xdut.xana.xsup.vdd_ok_5v xdut.gndd_p c=6.50781e-15
c43023_7 xdut.xana.xsup.vdd_ok_5v xdut.vdd_rdiv_dis c=1.82379e-15
c43023_3 xdut.xana.xsup.vdd_ok_5v xdut.gnd_p c=1.41442e-14
c43023_2 xdut.xana.xsup.vdd_ok_5v xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=2.16397e-15
cg43022_49 xdut.xana.xsup.vcc_ok_5v 0 c=5.75283e-15
c43022_48 xdut.xana.xsup.vcc_ok_5v xdut.xana.xsup.vcc_uv_5v c=3.64374e-15
c43022_44 xdut.xana.xsup.vcc_ok_5v xdut.xana.xsup.xvccreg.xcomp.enb c=1.3504e-15
c43022_43 xdut.xana.xsup.vcc_ok_5v xdut.xana.xsup.xvccreg.xcomp.net60 c=1.28551e-15
c43022_28 xdut.xana.xsup.vcc_ok_5v xdut.xana.xsup.vcc_nbl c=3.51124e-15
c43022_9 xdut.xana.xsup.vcc_ok_5v xdut.gndd_p c=2.75526e-14
c43022_3 xdut.xana.xsup.vcc_ok_5v xdut.gnd_p c=1.46283e-14
c43022_2 xdut.xana.xsup.vcc_ok_5v xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=2.43243e-15
cg42999_59 xdut.xana.xsup.vcc_nbl 0 c=2.04385e-13
c42999_54 xdut.xana.xsup.vcc_nbl xdut.xana.xsup.atst_sup_5v<4> c=2.88193e-15
c42999_38 xdut.xana.xsup.vcc_nbl xdut.xana.xsup.vrr_ok_5v c=1.57924e-15
c42999_35 xdut.xana.xsup.vcc_nbl xdut.xana.vdd_uv_5v c=1.50369e-15
c42999_24 xdut.xana.xsup.vcc_nbl xdut.gndd_p c=1.27246e-13
c42999_20 xdut.xana.xsup.vcc_nbl xdut.vdd_rdiv_dis c=2.15947e-15
c42999_7 xdut.xana.xsup.vcc_nbl xdut.reg_vdd_dis c=1.46466e-15
c42999_4 xdut.xana.xsup.vcc_nbl xdut.vsup_p c=1.512e-14
c42999_3 xdut.xana.xsup.vcc_nbl xdut.gnd_p c=1.3784e-13
c42999_2 xdut.xana.xsup.vcc_nbl xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=2.35497e-14
cg42903_25 xdut.xana.xotpmux.net314 0 c=2.51944e-14
c42903_15 xdut.xana.xotpmux.net314 xdut.xana.xotpmux.atst_otp_5v<4> c=6.28101e-15
c42903_8 xdut.xana.xotpmux.net314 xdut.gndd_p c=6.62307e-15
c42903_3 xdut.xana.xotpmux.net314 xdut.xana.xotpmux.dm11c c=1.03022e-14
c42903_2 xdut.xana.xotpmux.net314 xdut.gnd_p c=7.59654e-15
cg42695_45 xdut.xana.xldo.vfb_int 0 c=2.44807e-14
c42695_44 xdut.xana.xldo.vfb_int xdut.xana.xldo.xamp.cms c=4.81116e-15
c42695_40 xdut.xana.xldo.vfb_int xdut.xana.xldo.net636 c=4.36279e-15
c42695_38 xdut.xana.xldo.vfb_int xdut.xana.xldo.vlim_flt c=3.11288e-15
c42695_35 xdut.xana.xldo.vfb_int xdut.xana.xldo.net629 c=3.75378e-15
c42695_19 xdut.xana.xldo.vfb_int xdut.xana.xldo.vref c=2.11205e-14
c42695_18 xdut.xana.xldo.vfb_int xdut.xana.xldo.xamp.gl c=4.75085e-15
c42695_15 xdut.xana.xldo.vfb_int xdut.xana.xldo.xamp.gr c=1.98166e-15
c42695_14 xdut.xana.xldo.vfb_int xdut.xana.xldo.vdsi_off_5v c=8.98259e-15
c42695_13 xdut.xana.xldo.vfb_int xdut.xana.ln_ldo.n_1017 c=4.3734e-15
c42695_11 xdut.xana.xldo.vfb_int xdut.xana.ln_ldo.n_1014 c=4.68603e-15
c42695_9 xdut.xana.xldo.vfb_int xdut.xana.xldo.vdsi_fc c=1.13745e-15
c42695_8 xdut.xana.xldo.vfb_int xdut.xana.xldo.vs_m0 c=1.49046e-15
c42695_7 xdut.xana.xldo.vfb_int xdut.xana.xldo.vlim c=9.18539e-15
c42695_6 xdut.xana.xldo.vfb_int xdut.xana.xldo.vdsi_nbl c=2.31677e-15
c42695_4 xdut.xana.xldo.vfb_int xdut.cldo_p c=1.16816e-15
c42695_2 xdut.xana.xldo.vfb_int xdut.gnd_p c=1.11915e-14
c42695_1 xdut.xana.xldo.vfb_int xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.21204e-14
cg42694_28 xdut.xana.xldo.vdivh 0 c=1.29724e-14
c42694_27 xdut.xana.xldo.vdivh xdut.xana.xldo.vdivl c=1.10936e-14
c42694_25 xdut.xana.xldo.vdivh xdut.xana.xldo.vref_cmp c=1.36659e-14
c42694_24 xdut.xana.xldo.vdivh xdut.xana.xldo.i1u_cmp c=3.21973e-15
c42694_2 xdut.xana.xldo.vdivh xdut.gnd_p c=5.46454e-14
cg42693_26 xdut.xana.xldo.vdivl 0 c=1.04455e-14
c42693_24 xdut.xana.xldo.vdivl xdut.xana.xldo.vref_cmp c=1.10626e-14
c42693_23 xdut.xana.xldo.vdivl xdut.xana.xldo.i1u_cmp c=1.34855e-15
c42693_2 xdut.xana.xldo.vdivl xdut.gnd_p c=5.76453e-14
c42693_1 xdut.xana.xldo.vdivl xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=3.87794e-15
cg42688_26 xdut.xana.xldo.vref_cmp 0 c=1.1902e-14
c42688_24 xdut.xana.xldo.vref_cmp xdut.xana.xldo.xuvcomp.nn1 c=1.67462e-15
c42688_22 xdut.xana.xldo.vref_cmp xdut.xana.xldo.i1u_cmp c=4.61183e-15
c42688_14 xdut.xana.xldo.vref_cmp xdut.xana.xldo.xuvcomp.nn3 c=1.27194e-15
c42688_13 xdut.xana.xldo.vref_cmp xdut.xana.xldo.xuvcomp.inp c=2.22758e-15
c42688_2 xdut.xana.xldo.vref_cmp xdut.gnd_p c=4.6882e-14
c42688_1 xdut.xana.xldo.vref_cmp xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=2.36781e-15
cg42687_15 xdut.xana.xldo.i1u_cmp 0 c=6.24958e-15
c42687_10 xdut.xana.xldo.i1u_cmp xdut.xana.xldo.vdsi_ok_5v c=1.28288e-15
c42687_5 xdut.xana.xldo.i1u_cmp xdut.xana.ic5u<9> c=1.51618e-15
c42687_2 xdut.xana.xldo.i1u_cmp xdut.gnd_p c=2.03329e-15
c42687_1 xdut.xana.xldo.i1u_cmp xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.11624e-15
cg42685_10 xdut.xana.xldo.vgpass 0 c=6.88127e-14
c42685_7 xdut.xana.xldo.vgpass xdut.xana.xldo.net634 c=1.63184e-14
c42685_6 xdut.xana.xldo.vgpass xdut.xana.xldo.vd_msen c=1.89429e-15
c42685_5 xdut.xana.xldo.vgpass xdut.xana.xldo.vdsi_fc c=3.51587e-15
c42685_3 xdut.xana.xldo.vgpass xdut.gnd_dsi c=2.61239e-14
c42685_2 xdut.xana.xldo.vgpass xdut.cldo_p c=3.01996e-13
c42685_1 xdut.xana.xldo.vgpass xdut.vsup_p c=3.61315e-12
cg42668_17 xdut.xana.xldo.vlim_flt 0 c=2.69508e-14
c42668_16 xdut.xana.xldo.vlim_flt xdut.xana.xldo.net636 c=3.2742e-15
c42668_15 xdut.xana.xldo.vlim_flt xdut.xana.xldo.dm2 c=1.3773e-15
c42668_12 xdut.xana.xldo.vlim_flt xdut.xana.xldo.ota_out c=3.5523e-14
c42668_10 xdut.xana.xldo.vlim_flt xdut.xana.ln_ldo.n_1022 c=4.56715e-15
c42668_8 xdut.xana.xldo.vlim_flt xdut.xana.ln_ldo.n_1015 c=4.49224e-15
c42668_5 xdut.xana.xldo.vlim_flt xdut.xana.xldo.vlim c=7.0142e-15
c42668_2 xdut.xana.xldo.vlim_flt xdut.gnd_p c=2.30372e-14
c42668_1 xdut.xana.xldo.vlim_flt xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.33886e-15
c42663_7 xdut.xana.ln_ldo.n_461 xdut.xana.ln_ldo.n_458 c=4.80314e-15
c42663_1 xdut.xana.ln_ldo.n_461 xdut.gnd_p c=9.64471e-15
c42662_6 xdut.xana.ln_ldo.n_460 xdut.xana.ln_ldo.n_458 c=4.80392e-15
c42662_5 xdut.xana.ln_ldo.n_460 xdut.xana.xldo.vfb c=4.80947e-15
c42662_1 xdut.xana.ln_ldo.n_460 xdut.gnd_p c=4.81422e-15
c42661_10 xdut.xana.xldo.net630 xdut.xana.xldo.vfb c=2.84659e-14
c42661_9 xdut.xana.xldo.net630 xdut.xana.xldo.net629 c=1.02341e-15
c42661_1 xdut.xana.xldo.net630 xdut.gnd_p c=1.71242e-14
c42660_1 xdut.xana.ln_ldo.n_458 xdut.gnd_p c=4.87265e-15
c42659_8 xdut.xana.xldo.vfb xdut.xana.xldo.net629 c=2.78413e-15
c42659_7 xdut.xana.xldo.vfb xdut.xana.xldo.vdiv2 c=4.72008e-15
c42659_1 xdut.xana.xldo.vfb xdut.gnd_p c=2.38608e-14
cg42655_9 xdut.xana.xldo.net629 0 c=3.22756e-15
c42655_8 xdut.xana.xldo.net629 xdut.xana.xldo.vdiv2 c=1.02988e-14
c42655_5 xdut.xana.xldo.net629 xdut.xana.ln_ldo.n_1013 c=1.31804e-15
c42655_1 xdut.xana.xldo.net629 xdut.gnd_p c=1.70584e-14
cg42642_30 xdut.xana.xldo.vcc_nbl 0 c=1.17545e-14
c42642_17 xdut.xana.xldo.vcc_nbl xdut.xana.ic5u<9> c=6.5897e-15
c42642_13 xdut.xana.xldo.vcc_nbl xdut.gndd_p c=1.31295e-15
c42642_6 xdut.xana.xldo.vcc_nbl xdut.gnd_dsi c=7.44841e-14
c42642_5 xdut.xana.xldo.vcc_nbl xdut.cldo_p c=2.16655e-15
c42642_4 xdut.xana.xldo.vcc_nbl xdut.vsup_p c=8.04433e-15
c42642_3 xdut.xana.xldo.vcc_nbl xdut.gnd_p c=8.35533e-14
c42642_2 xdut.xana.xldo.vcc_nbl xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=2.61684e-15
cg42639_10 xdut.xana.xldo.net638 0 c=1.37828e-15
c42639_7 xdut.xana.xldo.net638 xdut.xana.xldo.xsw_atb.net28 c=1.22458e-15
c42639_2 xdut.xana.xldo.net638 xdut.gnd_p c=2.10585e-15
c42632_12 xdut.xana.xldo.xuvcomp.nn2 xdut.xana.xldo.xuvcomp.nn1 c=2.4722e-15
c42632_10 xdut.xana.xldo.xuvcomp.nn2 xdut.xana.xldo.xuvcomp.nn3 c=3.64779e-15
c42632_9 xdut.xana.xldo.xuvcomp.nn2 xdut.xana.xldo.xuvcomp.inp c=2.72495e-15
c42632_2 xdut.xana.xldo.xuvcomp.nn2 xdut.gnd_p c=4.46622e-15
c42632_1 xdut.xana.xldo.xuvcomp.nn2 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.24119e-15
cg42626_37 xdut.xana.xldo.vdsi_ok_5v 0 c=1.40878e-14
c42626_18 xdut.xana.xldo.vdsi_ok_5v xdut.xana.xldo.xuvcomp.net60 c=1.30194e-15
c42626_17 xdut.xana.xldo.vdsi_ok_5v xdut.xana.xldo.i5u_ota c=1.38666e-15
c42626_16 xdut.xana.xldo.vdsi_ok_5v xdut.xana.xldo.vref c=4.4873e-15
c42626_12 xdut.xana.xldo.vdsi_ok_5v xdut.xana.xldo.net641 c=1.68357e-15
c42626_11 xdut.xana.xldo.vdsi_ok_5v xdut.xana.xldo.xuvcomp.enb c=1.43573e-15
c42626_3 xdut.xana.xldo.vdsi_ok_5v xdut.gnd_p c=1.08101e-14
c42626_2 xdut.xana.xldo.vdsi_ok_5v xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=3.00731e-15
c42625_11 xdut.xana.xldo.xuvcomp.nn3 xdut.xana.xldo.xuvcomp.nn1 c=5.38596e-15
c42625_10 xdut.xana.xldo.xuvcomp.nn3 xdut.xana.xldo.xuvcomp.inp c=1.31899e-15
c42625_2 xdut.xana.xldo.xuvcomp.nn3 xdut.gnd_p c=3.7435e-15
c42625_1 xdut.xana.xldo.xuvcomp.nn3 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.09977e-15
c42624_9 xdut.xana.xldo.xuvcomp.inp xdut.xana.xldo.xuvcomp.nn1 c=1.15874e-15
c42624_1 xdut.xana.xldo.xuvcomp.inp xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=2.65443e-15
cg42623_11 xdut.xana.xldo.xuvcomp.nn4 0 c=1.36369e-15
c42623_5 xdut.xana.xldo.xuvcomp.nn4 xdut.xana.xldo.xuvcomp.nn6 c=2.69694e-15
c42623_3 xdut.xana.xldo.xuvcomp.nn4 xdut.xana.xldo.xuvcomp.enb c=3.32442e-15
c42623_2 xdut.xana.xldo.xuvcomp.nn4 xdut.gnd_p c=1.30932e-15
cg42622_15 xdut.xana.xldo.xuvcomp.nnvc 0 c=9.40446e-15
c42622_6 xdut.xana.xldo.xuvcomp.nnvc xdut.xana.xldo.xuvcomp.nn6 c=1.60815e-15
c42622_2 xdut.xana.xldo.xuvcomp.nnvc xdut.gnd_p c=8.21869e-14
c42622_1 xdut.xana.xldo.xuvcomp.nnvc xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.96469e-15
cg42621_10 xdut.xana.xldo.xuvcomp.nn6 0 c=1.50649e-15
c42621_6 xdut.xana.xldo.xuvcomp.nn6 xdut.xana.xldo.xuvcomp.net60 c=1.87442e-15
c42621_2 xdut.xana.xldo.xuvcomp.nn6 xdut.gnd_p c=5.57017e-15
cg42614_75 xdut.xana.xldo.vref 0 c=2.40651e-14
c42614_71 xdut.xana.xldo.vref xdut.xana.xldo.xvref.net30 c=1.44306e-15
c42614_69 xdut.xana.xldo.vref xdut.xana.xldo.xvref.net34 c=2.44361e-15
c42614_67 xdut.xana.xldo.vref xdut.xana.xldo.xvref.net38 c=1.35192e-15
c42614_65 xdut.xana.xldo.vref xdut.xana.xldo.xvref.net42 c=2.51189e-15
c42614_63 xdut.xana.xldo.vref xdut.xana.xldo.xvref.net46 c=1.334e-15
c42614_61 xdut.xana.xldo.vref xdut.xana.xldo.xvref.net50 c=1.42931e-15
c42614_59 xdut.xana.xldo.vref xdut.xana.xldo.xvref.net211 c=4.70899e-15
c42614_43 xdut.xana.xldo.vref xdut.xana.xldo.xamp.cms c=4.80147e-15
c42614_30 xdut.xana.xldo.vref xdut.xana.xldo.i5u_ota c=5.18282e-15
c42614_29 xdut.xana.xldo.vref xdut.xana.xldo.xamp.vpb c=2.85552e-15
c42614_24 xdut.xana.xldo.vref xdut.xana.xldo.xamp.gr c=4.31054e-15
c42614_23 xdut.xana.xldo.vref xdut.xana.xldo.vdsi_off_5v c=4.69955e-15
c42614_9 xdut.xana.xldo.vref xdut.xana.vbg_buf c=4.1508e-15
c42614_3 xdut.xana.xldo.vref xdut.gnd_p c=7.88228e-14
c42614_2 xdut.xana.xldo.vref xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=7.01373e-15
c42592_5 xdut.xana.xldo.net641 xdut.xana.xldo.xuvcomp.net60 c=1.43908e-15
c42583_2 xdut.xana.xldo.xuvcomp.enb xdut.gnd_p c=1.83248e-15
c42583_1 xdut.xana.xldo.xuvcomp.enb xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=3.74926e-15
cg42014_12 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2388 0 c=8.26211e-15
c42014_1 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2388 xdut.gnd_dsi c=3.22147e-14
cg42013_19 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net1294 0 c=1.20866e-15
c42013_2 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net1294 xdut.gnd_dsi c=3.31968e-14
cg42011_16 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2652 0 c=3.07202e-15
c42011_2 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2652 xdut.gnd_dsi c=1.9175e-14
c42010_2 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2668 xdut.gnd_dsi c=1.59191e-14
c42004_2 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vpgo xdut.gnd_dsi c=5.20451e-15
cg42002_40 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2530 0 c=1.06059e-13
c42002_3 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2530 xdut.gnd_dsi c=1.08289e-13
c42002_2 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2530 xdut.dsi1_p c=3.67269e-15
cg41992_29 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vbnc_5v 0 c=3.33913e-14
c41992_2 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vbnc_5v xdut.gnd_dsi c=5.82922e-14
cg41991_12 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2390 0 c=7.94584e-15
c41991_2 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2390 xdut.gnd_dsi c=4.4898e-14
cg41568_29 xdut.xana.xdsi_ch1<1>.xtx.vbp5v_12v 0 c=4.4303e-14
c41568_12 xdut.xana.xdsi_ch1<1>.xtx.vbp5v_12v xdut.xana.xdsi_ch1<0>.xtx.vcc_nbl c=2.65884e-15
c41568_4 xdut.xana.xdsi_ch1<1>.xtx.vbp5v_12v xdut.gnd_dsi c=1.64096e-13
c41568_3 xdut.xana.xdsi_ch1<1>.xtx.vbp5v_12v xdut.dsi1_p c=4.08742e-15
c41568_2 xdut.xana.xdsi_ch1<1>.xtx.vbp5v_12v xdut.xana.xdsi_ch1<1>.vsup_dsi c=3.99011e-13
c41555_3 xdut.xana.xdsi_ch1<1>.xtx.atst_tx_5v<0> xdut.gnd_dsi c=3.92312e-15
c41554_4 xdut.xana.xdsi_ch1<1>.xtx.atst_tx_5v<4> xdut.aout_int c=5.25296e-15
c41554_3 xdut.xana.xdsi_ch1<1>.xtx.atst_tx_5v<4> xdut.gnd_dsi c=2.5047e-15
c41553_3 xdut.xana.xdsi_ch1<1>.xtx.atst_tx_5v<3> xdut.gnd_dsi c=3.15969e-15
c41552_3 xdut.xana.xdsi_ch1<1>.xtx.atst_tx_5v<2> xdut.gnd_dsi c=6.47181e-15
cg41536_36 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vnco 0 c=8.03829e-14
c41536_2 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vnco xdut.gnd_dsi c=9.30439e-13
cg41532_48 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vbn_5v 0 c=9.75423e-15
c41532_3 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vbn_5v xdut.aout_int c=2.83902e-15
c41532_2 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vbn_5v xdut.gnd_dsi c=5.26173e-14
cg41527_121 xdut.xana.xdsi_ch1<1>.xtx.i_dac_5v 0 c=1.67996e-14
c41527_9 xdut.xana.xdsi_ch1<1>.xtx.i_dac_5v xdut.xana.cldo_dsi<1> c=2.94907e-13
c41527_6 xdut.xana.xdsi_ch1<1>.xtx.i_dac_5v xdut.aout_int c=1.24917e-14
c41527_4 xdut.xana.xdsi_ch1<1>.xtx.i_dac_5v xdut.gnd_dsi c=5.05694e-12
c41527_3 xdut.xana.xdsi_ch1<1>.xtx.i_dac_5v xdut.dsi1_p c=5.33754e-15
c41527_2 xdut.xana.xdsi_ch1<1>.xtx.i_dac_5v xdut.xana.xdsi_ch1<1>.vsup_dsi c=1.7016e-13
c41519_3 xdut.xana.xdsi_ch1<1>.xtx.vdsi_ok_5v xdut.gnd_dsi c=7.7277e-15
cg41497_87 xdut.xana.xdsi_ch1<1>.xtx.on_tx_hvcasc_5v 0 c=1.05753e-15
c41497_4 xdut.xana.xdsi_ch1<1>.xtx.on_tx_hvcasc_5v xdut.gnd_dsi c=3.3203e-14
c41493_4 xdut.xana.xdsi_ch1<1>.xtx.on_tx_5v xdut.aout_int c=1.34658e-15
c41493_3 xdut.xana.xdsi_ch1<1>.xtx.on_tx_5v xdut.gnd_dsi c=1.02217e-14
c41476_2 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vnc2 xdut.gnd_dsi c=5.05586e-14
cg41475_49 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vngo 0 c=1.04611e-15
c41475_3 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vngo xdut.aout_int c=2.2194e-15
c41475_2 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vngo xdut.gnd_dsi c=1.79167e-13
cg41473_38 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vncin2 0 c=3.16284e-15
c41473_2 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vncin2 xdut.gnd_dsi c=3.09529e-14
cg41458_52 xdut.xana.xdsi_ch1<1>.xtx.tx_cfg_5v<1> 0 c=1.03922e-15
c41458_12 xdut.xana.xdsi_ch1<1>.xtx.tx_cfg_5v<1> xdut.xana.irp10u<1> c=2.14461e-15
c41458_11 xdut.xana.xdsi_ch1<1>.xtx.tx_cfg_5v<1> xdut.xana.ic5u<1> c=1.98929e-15
c41458_7 xdut.xana.xdsi_ch1<1>.xtx.tx_cfg_5v<1> xdut.dsi_tx_tbit_cfg<2> c=1.01098e-15
c41458_5 xdut.xana.xdsi_ch1<1>.xtx.tx_cfg_5v<1> xdut.gnd_dsi c=2.08113e-14
c41458_4 xdut.xana.xdsi_ch1<1>.xtx.tx_cfg_5v<1> xdut.dsi1_p c=1.42672e-15
c41454_8 xdut.xana.xdsi_ch1<1>.xtx.tx_cfg_5v<0> xdut.dsi_rx_txn<1> c=1.0365e-15
c41454_5 xdut.xana.xdsi_ch1<1>.xtx.tx_cfg_5v<0> xdut.gnd_dsi c=1.65722e-14
c41448_3 xdut.xana.xdsi_ch1<1>.xtx.vdsi_ctrl_5v<2> xdut.gnd_dsi c=4.43437e-15
c41443_3 xdut.xana.xdsi_ch1<1>.xtx.vdsi_ctrl_5v<1> xdut.gnd_dsi c=3.55566e-15
c41437_6 xdut.xana.xdsi_ch1<1>.xtx.vdsi_ctrl_5v<0> xdut.xana.irp10u<1> c=3.13353e-15
c41437_3 xdut.xana.xdsi_ch1<1>.xtx.vdsi_ctrl_5v<0> xdut.gnd_dsi c=5.53347e-15
c41425_20 xdut.xana.xdsi_ch1<1>.xtx.rx_txn_5v xdut.xana.xdsi_ch1<0>.xtx.vcc_nbl c=1.02372e-15
c41425_5 xdut.xana.xdsi_ch1<1>.xtx.rx_txn_5v xdut.gnd_dsi c=1.76348e-14
cg41386_45 xdut.xana.xdsi_ch1<0>.xtx.vcc_nbl 0 c=4.32775e-14
c41386_12 xdut.xana.xdsi_ch1<0>.xtx.vcc_nbl xdut.xana.xdsi_ch1<1>.net292 c=7.11327e-15
c41386_9 xdut.xana.xdsi_ch1<0>.xtx.vcc_nbl xdut.xana.irp10u<1> c=2.11412e-15
c41386_8 xdut.xana.xdsi_ch1<0>.xtx.vcc_nbl xdut.xana.ic5u<1> c=3.00914e-15
c41386_6 xdut.xana.xdsi_ch1<0>.xtx.vcc_nbl xdut.aout_int c=3.14664e-15
c41386_5 xdut.xana.xdsi_ch1<0>.xtx.vcc_nbl xdut.gnd_dsi c=7.67657e-13
c41386_3 xdut.xana.xdsi_ch1<0>.xtx.vcc_nbl xdut.xana.xdsi_ch1<1>.vsup_dsi c=2.74049e-15
c41366_4 xdut.xana.xdsi_ch1<1>.xtx.atst_tx_5v<5> xdut.aout_int c=5.61031e-15
c41366_3 xdut.xana.xdsi_ch1<1>.xtx.atst_tx_5v<5> xdut.gnd_dsi c=7.03013e-15
c41331_3 xdut.xana.xdsi_ch1<1>.xtx.atst_tx_5v<1> xdut.gnd_dsi c=2.32524e-15
cg41330_18 xdut.xana.xdsi_ch1<1>.net292 0 c=8.64578e-14
c41330_9 xdut.xana.xdsi_ch1<1>.net292 xdut.xana.cldo_dsi<1> c=5.3631e-15
c41330_7 xdut.xana.xdsi_ch1<1>.net292 xdut.xana.ic5u<1> c=1.36956e-14
c41330_4 xdut.xana.xdsi_ch1<1>.net292 xdut.gnd_dsi c=1.58547e-14
c41330_3 xdut.xana.xdsi_ch1<1>.net292 xdut.xana.xdsi_ch1<1>.vsup_dsi c=1.45681e-14
c41328_2 xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_99 xdut.gnd_dsi c=1.85393e-15
c41296_2 xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_26 xdut.gnd_dsi c=1.80509e-15
c41296_1 xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_26 xdut.dsi1_p c=3.66831e-15
c41294_2 xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_23 xdut.gnd_dsi c=1.80699e-15
c41294_1 xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_23 xdut.dsi1_p c=2.20259e-15
c41288_2 xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_100 xdut.gnd_dsi c=1.85245e-15
c41288_1 xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_100 xdut.dsi1_p c=1.5989e-15
cg41062_22 xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.coms1 0 c=1.19281e-15
c41059_2 xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.xst.net70 xdut.gnd_dsi c=1.72583e-15
c41057_2 xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.cmp_out_dig xdut.gnd_dsi c=1.3693e-15
c41052_2 xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.cmp_out_ana xdut.gnd_dsi c=4.10151e-15
c41044_2 xdut.xana.ln_dsi_ch1<1>.rx.iq_cmp.n_381 xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd c=1.3414e-15
c41044_1 xdut.xana.ln_dsi_ch1<1>.rx.iq_cmp.n_381 xdut.gnd_dsi c=1.12854e-15
c41043_4 xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.n4 xdut.xana.xdsi_ch1<1>.xrx.vhs_sup c=1.78431e-15
c41043_3 xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.n4 xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd c=4.28972e-15
c41043_2 xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.n4 xdut.gnd_dsi c=2.66762e-15
c41037_5 xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.n3 xdut.xana.xdsi_ch1<1>.xrx.vhs_sup c=1.29432e-15
c41037_4 xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.n3 xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd c=7.7661e-15
c41037_3 xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.n3 xdut.gnd_dsi c=6.20827e-15
c41037_2 xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.n3 xdut.gnd_p c=1.26024e-15
cg41022_16 xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.net462 0 c=1.76012e-15
c41022_1 xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.net462 xdut.gnd_dsi c=1.68225e-15
cg41019_12 xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.preamp_r 0 c=1.09038e-15
c41018_1 xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.preamp_l xdut.gnd_dsi c=1.05979e-15
c40776_1 xdut.xana.ln_dsi_ch1<1>.rx.dat1_cmp.n_367 xdut.gnd_dsi c=1.12086e-15
cg40757_18 xdut.xana.xdsi_ch1<1>.xrx.xdat1_cmp.net462 0 c=1.33971e-15
c40757_1 xdut.xana.xdsi_ch1<1>.xrx.xdat1_cmp.net462 xdut.gnd_dsi c=1.50218e-15
c40748_3 xdut.xana.xdsi_ch1<1>.xrx.idac_5v<1> xdut.gnd_dsi c=5.31134e-15
c40746_34 xdut.xana.xdsi_ch1<1>.xrx.rxd1_5v xdut.xana.xdsi_ch1<1>.xrx.rxd2_5v c=3.11344e-14
c40746_33 xdut.xana.xdsi_ch1<1>.xrx.rxd1_5v xdut.xana.xdsi_ch1<1>.xrx.iq_cmp_5v c=1.91488e-14
c40746_30 xdut.xana.xdsi_ch1<1>.xrx.rxd1_5v xdut.xana.xdsi_ch1<1>.xrx.mask_dcmp c=1.12228e-14
c40746_20 xdut.xana.xdsi_ch1<1>.xrx.rxd1_5v xdut.xana.xdsi_ch1<1>.xrx.inp_iq_s c=1.05936e-15
c40746_4 xdut.xana.xdsi_ch1<1>.xrx.rxd1_5v xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd c=1.40304e-15
c40746_3 xdut.xana.xdsi_ch1<1>.xrx.rxd1_5v xdut.gnd_dsi c=1.79342e-14
c40745_23 xdut.xana.xdsi_ch1<1>.xrx.iq_cmp_5v xdut.xana.xdsi_ch1<1>.xrx.rxd2_5v c=1.95024e-15
c40745_17 xdut.xana.xdsi_ch1<1>.xrx.iq_cmp_5v xdut.xana.xdsi_ch1<1>.xrx.on_5v c=1.00716e-15
c40745_13 xdut.xana.xdsi_ch1<1>.xrx.iq_cmp_5v xdut.xana.xdsi_ch1<1>.xrx.inn_iq c=2.94119e-15
c40745_4 xdut.xana.xdsi_ch1<1>.xrx.iq_cmp_5v xdut.gnd_dsi c=1.96181e-14
c40744_2 xdut.xana.xdsi_ch1<1>.xrx.idac_5v<0> xdut.gnd_dsi c=5.77544e-15
c40743_4 xdut.xana.xdsi_ch1<1>.xrx.idac_5v<2> xdut.gnd_dsi c=6.66784e-15
c40742_32 xdut.xana.xdsi_ch1<1>.xrx.mask_dcmp xdut.xana.xdsi_ch1<1>.xrx.rxd2_5v c=9.97977e-15
c40742_15 xdut.xana.xdsi_ch1<1>.xrx.mask_dcmp xdut.xana.xdsi_ch1<1>.xrx.on_5v c=3.45616e-14
c40742_4 xdut.xana.xdsi_ch1<1>.xrx.mask_dcmp xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd c=7.00193e-15
c40742_3 xdut.xana.xdsi_ch1<1>.xrx.mask_dcmp xdut.gnd_dsi c=1.64116e-14
c40707_20 xdut.xana.xdsi_ch1<1>.xrx.inp_iqcmp xdut.xana.xdsi_ch1<1>.xrx.net899 c=1.29381e-15
c40707_18 xdut.xana.xdsi_ch1<1>.xrx.inp_iqcmp xdut.xana.xdsi_ch1<1>.xrx.vhs_sup c=9.32369e-15
c40707_17 xdut.xana.xdsi_ch1<1>.xrx.inp_iqcmp xdut.xana.xdsi_ch1<1>.xrx.inp_iq_s c=1.3929e-14
c40707_16 xdut.xana.xdsi_ch1<1>.xrx.inp_iqcmp xdut.xana.xdsi_ch1<1>.xrx.inp_iq c=3.34651e-15
c40707_5 xdut.xana.xdsi_ch1<1>.xrx.inp_iqcmp xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd c=1.0177e-13
c40707_4 xdut.xana.xdsi_ch1<1>.xrx.inp_iqcmp xdut.gnd_dsi c=7.15552e-15
cg40683_35 xdut.xana.xdsi_ch1<1>.xrx.inn_iqcmp 0 c=1.71186e-15
c40683_19 xdut.xana.xdsi_ch1<1>.xrx.inn_iqcmp xdut.xana.xdsi_ch1<1>.xrx.net899 c=2.42451e-15
c40683_18 xdut.xana.xdsi_ch1<1>.xrx.inn_iqcmp xdut.xana.xdsi_ch1<1>.xrx.vhs_sup c=1.21277e-14
c40683_17 xdut.xana.xdsi_ch1<1>.xrx.inn_iqcmp xdut.xana.xdsi_ch1<1>.xrx.inp_iq_s c=1.17789e-15
c40683_16 xdut.xana.xdsi_ch1<1>.xrx.inn_iqcmp xdut.xana.xdsi_ch1<1>.xrx.inp_iq c=2.54848e-15
c40683_5 xdut.xana.xdsi_ch1<1>.xrx.inn_iqcmp xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd c=1.04981e-13
c40683_4 xdut.xana.xdsi_ch1<1>.xrx.inn_iqcmp xdut.gnd_dsi c=1.20944e-14
c40669_9 xdut.xana.xdsi_ch1<1>.xrx.inn_d1cmp xdut.xana.xdsi_ch1<1>.xrx.vhs_sup c=6.08534e-15
c40669_3 xdut.xana.xdsi_ch1<1>.xrx.inn_d1cmp xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd c=1.13066e-13
c40669_2 xdut.xana.xdsi_ch1<1>.xrx.inn_d1cmp xdut.gnd_dsi c=8.74472e-15
c40668_7 xdut.xana.xdsi_ch1<1>.xrx.inp_d1cmp xdut.xana.xdsi_ch1<1>.xrx.vhs_sup c=1.04155e-14
c40668_2 xdut.xana.xdsi_ch1<1>.xrx.inp_d1cmp xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd c=1.08965e-13
c40668_1 xdut.xana.xdsi_ch1<1>.xrx.inp_d1cmp xdut.gnd_dsi c=1.09892e-14
c40667_1 xdut.xana.xdsi_ch1<1>.xrx.flt_fast_hs_b xdut.gnd_dsi c=3.56146e-15
cg40662_78 xdut.xana.xdsi_ch1<1>.xrx.on_5v 0 c=1.44748e-15
c40662_19 xdut.xana.xdsi_ch1<1>.xrx.on_5v xdut.xana.xdsi_ch1<1>.xrx.vhs_sup c=3.06784e-15
c40662_18 xdut.xana.xdsi_ch1<1>.xrx.on_5v xdut.xana.xdsi_ch1<1>.xrx.flt_fast_5v c=2.50261e-15
c40662_17 xdut.xana.xdsi_ch1<1>.xrx.on_5v xdut.xana.xdsi_ch1<1>.xrx.inp_iq_s c=1.28765e-15
c40662_4 xdut.xana.xdsi_ch1<1>.xrx.on_5v xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd c=1.61486e-14
c40662_3 xdut.xana.xdsi_ch1<1>.xrx.on_5v xdut.gnd_dsi c=5.58908e-14
c40640_2 xdut.xana.xdsi_ch1<1>.xrx.xdat1_cmp.n2 xdut.gnd_dsi c=3.10925e-15
c40628_2 xdut.xana.xdsi_ch1<1>.xrx.xdat1_cmp.n1 xdut.gnd_dsi c=3.0414e-15
cg40622_240 xdut.xana.xdsi_ch1<1>.xrx.vhs_sup 0 c=4.45017e-14
c40622_76 xdut.xana.xdsi_ch1<1>.xrx.vhs_sup xdut.xana.xdsi_ch1<1>.xrx.net899 c=5.06706e-15
c40622_68 xdut.xana.xdsi_ch1<1>.xrx.vhs_sup xdut.xana.xdsi_ch1<1>.xrx.inn_d2cmp c=6.97676e-15
c40622_56 xdut.xana.xdsi_ch1<1>.xrx.vhs_sup xdut.xana.xdsi_ch1<1>.xrx.inp_d2cmp c=1.42022e-14
c40622_44 xdut.xana.xdsi_ch1<1>.xrx.vhs_sup xdut.xana.xdsi_ch1<1>.xrx.inp_iq_s c=8.68509e-15
c40622_43 xdut.xana.xdsi_ch1<1>.xrx.vhs_sup xdut.xana.xdsi_ch1<1>.xrx.inp_iq c=6.21051e-15
c40622_40 xdut.xana.xdsi_ch1<1>.xrx.vhs_sup xdut.xana.xdsi_ch1<1>.xrx.inn_iq c=7.92393e-15
c40622_37 xdut.xana.xdsi_ch1<1>.xrx.vhs_sup xdut.xana.xdsi_ch1<1>.xrx.idac_5v<4> c=3.13136e-15
c40622_36 xdut.xana.xdsi_ch1<1>.xrx.vhs_sup xdut.xana.xdsi_ch1<1>.xrx.idac_5v<3> c=2.12393e-15
c40622_25 xdut.xana.xdsi_ch1<1>.xrx.vhs_sup xdut.xana.ic5u<10> c=4.03446e-15
c40622_23 xdut.xana.xdsi_ch1<1>.xrx.vhs_sup xdut.gndd_p c=3.19985e-15
c40622_9 xdut.xana.xdsi_ch1<1>.xrx.vhs_sup xdut.otp_vrr c=3.23128e-15
c40622_8 xdut.xana.xdsi_ch1<1>.xrx.vhs_sup xdut.aout_int c=1.3533e-15
c40622_6 xdut.xana.xdsi_ch1<1>.xrx.vhs_sup xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd c=2.54557e-12
c40622_5 xdut.xana.xdsi_ch1<1>.xrx.vhs_sup xdut.gnd_dsi c=1.2994e-12
c40622_3 xdut.xana.xdsi_ch1<1>.xrx.vhs_sup xdut.gnd_p c=4.96324e-14
cg40590_21 xdut.xana.xdsi_ch1<1>.xrx.inp_iq_s 0 c=1.12656e-15
c40590_17 xdut.xana.xdsi_ch1<1>.xrx.inp_iq_s xdut.xana.xdsi_ch1<1>.xrx.inp_iq c=7.31528e-14
c40590_14 xdut.xana.xdsi_ch1<1>.xrx.inp_iq_s xdut.xana.xdsi_ch1<1>.xrx.inn_iq c=5.95607e-15
c40590_8 xdut.xana.xdsi_ch1<1>.xrx.inp_iq_s xdut.gndd_p c=1.87537e-15
c40590_5 xdut.xana.xdsi_ch1<1>.xrx.inp_iq_s xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd c=1.10555e-14
c40590_4 xdut.xana.xdsi_ch1<1>.xrx.inp_iq_s xdut.gnd_dsi c=3.80948e-14
cg40583_35 xdut.xana.xdsi_ch1<1>.xrx.inp_iq 0 c=1.56982e-14
c40583_33 xdut.xana.xdsi_ch1<1>.xrx.inp_iq xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_74 c=1.37999e-15
c40583_24 xdut.xana.xdsi_ch1<1>.xrx.inp_iq xdut.xana.xdsi_ch1<1>.xrx.rxd2_5v c=1.56382e-15
c40583_19 xdut.xana.xdsi_ch1<1>.xrx.inp_iq xdut.xana.xdsi_ch1<1>.xrx.inn_iq c=7.38908e-14
c40583_11 xdut.xana.xdsi_ch1<1>.xrx.inp_iq xdut.gndd_p c=2.16883e-15
c40583_9 xdut.xana.xdsi_ch1<1>.xrx.inp_iq xdut.aout_int c=1.09941e-15
c40583_6 xdut.xana.xdsi_ch1<1>.xrx.inp_iq xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd c=2.93929e-15
c40583_5 xdut.xana.xdsi_ch1<1>.xrx.inp_iq xdut.gnd_dsi c=3.88287e-14
c40583_3 xdut.xana.xdsi_ch1<1>.xrx.inp_iq xdut.gnd_p c=1.05438e-15
cg40582_42 xdut.xana.xdsi_ch1<1>.xrx.inp_dat2_cmp 0 c=2.81131e-14
c40582_3 xdut.xana.xdsi_ch1<1>.xrx.inp_dat2_cmp xdut.gnd_dsi c=6.92086e-14
c40582_2 xdut.xana.xdsi_ch1<1>.xrx.inp_dat2_cmp xdut.dsi1_p c=1.63631e-15
cg40581_33 xdut.xana.xdsi_ch1<1>.xrx.inp_dat1_cmp 0 c=2.2844e-14
c40581_6 xdut.xana.xdsi_ch1<1>.xrx.inp_dat1_cmp xdut.xana.ic5u<5> c=1.23e-15
c40581_3 xdut.xana.xdsi_ch1<1>.xrx.inp_dat1_cmp xdut.gnd_dsi c=8.73629e-14
c40581_2 xdut.xana.xdsi_ch1<1>.xrx.inp_dat1_cmp xdut.dsi1_p c=3.28553e-15
cg40580_22 xdut.xana.xdsi_ch1<1>.xrx.inn_iq 0 c=1.14434e-14
c40580_19 xdut.xana.xdsi_ch1<1>.xrx.inn_iq xdut.xana.xdsi_ch1<1>.xrx.xflt3.net6 c=4.52221e-15
c40580_15 xdut.xana.xdsi_ch1<1>.xrx.inn_iq xdut.xana.xdsi_ch1<1>.xrx.idac_5v<4> c=9.15498e-15
c40580_12 xdut.xana.xdsi_ch1<1>.xrx.inn_iq xdut.xana.vdd_uv_5v c=1.75412e-15
c40580_10 xdut.xana.xdsi_ch1<1>.xrx.inn_iq xdut.gndd_p c=9.28309e-15
c40580_8 xdut.xana.xdsi_ch1<1>.xrx.inn_iq xdut.aout_int c=2.15883e-15
c40580_6 xdut.xana.xdsi_ch1<1>.xrx.inn_iq xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd c=1.6433e-14
c40580_5 xdut.xana.xdsi_ch1<1>.xrx.inn_iq xdut.gnd_dsi c=4.75707e-14
c40580_3 xdut.xana.xdsi_ch1<1>.xrx.inn_iq xdut.gnd_p c=1.7257e-15
cg40578_22 xdut.xana.xdsi_ch1<1>.xrx.inn_dat2_cmp 0 c=2.18061e-14
c40578_3 xdut.xana.xdsi_ch1<1>.xrx.inn_dat2_cmp xdut.gnd_dsi c=5.58119e-14
c40578_2 xdut.xana.xdsi_ch1<1>.xrx.inn_dat2_cmp xdut.dsi1_p c=1.82815e-15
cg40577_37 xdut.xana.xdsi_ch1<1>.xrx.inn_dat1_cmp 0 c=6.55679e-15
c40577_3 xdut.xana.xdsi_ch1<1>.xrx.inn_dat1_cmp xdut.gnd_dsi c=5.35129e-14
c40577_2 xdut.xana.xdsi_ch1<1>.xrx.inn_dat1_cmp xdut.dsi1_p c=3.27262e-15
c40576_4 xdut.xana.xdsi_ch1<1>.xrx.idac_5v<4> xdut.gnd_dsi c=3.10782e-15
c40575_3 xdut.xana.xdsi_ch1<1>.xrx.idac_5v<3> xdut.gnd_dsi c=4.38026e-15
c40574_7 xdut.xana.xdsi_ch1<1>.xrx.idac2atb_5v xdut.dsi_idac<5> c=1.5225e-15
c40574_4 xdut.xana.xdsi_ch1<1>.xrx.idac2atb_5v xdut.gnd_dsi c=1.24711e-14
cg792_57 xdut.xana.xdsi_ch1<0>.vshunt_h 0 c=7.87449e-13
c792_49 xdut.xana.xdsi_ch1<0>.vshunt_h xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_96 c=1.82584e-15
c792_46 xdut.xana.xdsi_ch1<0>.vshunt_h xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_93 c=1.53673e-15
c792_44 xdut.xana.xdsi_ch1<0>.vshunt_h xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_91 c=1.60925e-15
c792_43 xdut.xana.xdsi_ch1<0>.vshunt_h xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_90 c=1.45634e-15
c792_42 xdut.xana.xdsi_ch1<0>.vshunt_h xdut.xana.xdsi_ch1<0>.xrx.xrshunt.net1142 c=1.03814e-15
c792_40 xdut.xana.xdsi_ch1<0>.vshunt_h xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_88 c=1.98845e-15
c792_37 xdut.xana.xdsi_ch1<0>.vshunt_h xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_85 c=1.53603e-15
c792_35 xdut.xana.xdsi_ch1<0>.vshunt_h xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_83 c=1.45699e-15
c792_33 xdut.xana.xdsi_ch1<0>.vshunt_h xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_81 c=1.45627e-15
c792_32 xdut.xana.xdsi_ch1<0>.vshunt_h xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_77 c=1.82599e-15
c792_29 xdut.xana.xdsi_ch1<0>.vshunt_h xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_74 c=1.44597e-15
c792_27 xdut.xana.xdsi_ch1<0>.vshunt_h xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_72 c=1.45682e-15
c792_25 xdut.xana.xdsi_ch1<0>.vshunt_h xdut.xana.xdsi_ch1<0>.xrx.xrshunt.net1151 c=1.36557e-15
c792_24 xdut.xana.xdsi_ch1<0>.vshunt_h xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_65 c=1.95494e-15
c792_23 xdut.xana.xdsi_ch1<0>.vshunt_h xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_64 c=1.34206e-15
c792_21 xdut.xana.xdsi_ch1<0>.vshunt_h xdut.xana.xdsi_ch1<0>.xrx.xrshunt.net1154 c=1.42708e-15
c792_19 xdut.xana.xdsi_ch1<0>.vshunt_h xdut.xana.xdsi_ch1<0>.xrx.xrshunt.net1149 c=4.22175e-15
c792_18 xdut.xana.xdsi_ch1<0>.vshunt_h xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_24 c=3.58492e-15
c792_17 xdut.xana.xdsi_ch1<0>.vshunt_h xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_22 c=2.29385e-15
c792_16 xdut.xana.xdsi_ch1<0>.vshunt_h xdut.xana.xdsi_ch1<0>.xrx.xrshunt.net1139 c=2.13038e-15
c792_15 xdut.xana.xdsi_ch1<0>.vshunt_h xdut.xana.xdsi_ch1<0>.xrx.xrshunt.net1140 c=1.3904e-15
c792_13 xdut.xana.xdsi_ch1<0>.vshunt_h xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_101 c=1.60731e-15
c792_4 xdut.xana.xdsi_ch1<0>.vshunt_h xdut.gnd_dsi c=8.69157e-13
c792_3 xdut.xana.xdsi_ch1<0>.vshunt_h xdut.dsi0_p c=6.08415e-13
c792_2 xdut.xana.xdsi_ch1<0>.vshunt_h xdut.xana.xdsi_ch1<0>.vsup_dsi c=2.30521e-13
c792_1 xdut.xana.xdsi_ch1<0>.vshunt_h xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd c=2.64757e-15
cg789_18 xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim2.idat_os_summe 0 c=2.75651e-15
c789_3 xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim2.idat_os_summe xdut.gnd_dsi c=6.22773e-15
cg788_20 xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim1.idat_os_summe 0 c=2.85814e-15
c788_3 xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim1.idat_os_summe xdut.gnd_dsi c=6.21703e-15
c786_3 xdut.xana.xdsi_ch1<0>.xrx.xdat1_cmp.n4 xdut.gnd_dsi c=5.46788e-15
c786_2 xdut.xana.xdsi_ch1<0>.xrx.xdat1_cmp.n4 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd c=6.12054e-15
c785_3 xdut.xana.xdsi_ch1<0>.xrx.xdat1_cmp.n3 xdut.gnd_dsi c=1.18565e-14
c785_2 xdut.xana.xdsi_ch1<0>.xrx.xdat1_cmp.n3 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd c=6.7296e-15
c784_3 xdut.xana.xdsi_ch1<0>.xrx.xdat2_cmp.n3 xdut.gnd_dsi c=1.18511e-14
c784_2 xdut.xana.xdsi_ch1<0>.xrx.xdat2_cmp.n3 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd c=6.73016e-15
c783_3 xdut.xana.xdsi_ch1<0>.xrx.xdat2_cmp.n4 xdut.gnd_dsi c=5.47358e-15
c783_2 xdut.xana.xdsi_ch1<0>.xrx.xdat2_cmp.n4 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd c=6.12359e-15
cg782_4 xdut.xana.xdsi_ch1<0>.xrx.xhs_sup.mphv_reg_d 0 c=2.77243e-15
c782_2 xdut.xana.xdsi_ch1<0>.xrx.xhs_sup.mphv_reg_d xdut.gnd_dsi c=1.04732e-14
cg781_11 xdut.xana.xdsi_ch1<0>.xrx.xhs_sup.vreg_ref 0 c=1.21995e-15
c781_2 xdut.xana.xdsi_ch1<0>.xrx.xhs_sup.vreg_ref xdut.gnd_dsi c=1.11857e-14
cg779_33 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vpnc2 0 c=2.26264e-14
c779_5 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vpnc2 xdut.aout_int c=1.45979e-15
c779_4 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vpnc2 xdut.gnd_dsi c=1.10769e-13
cg777_30 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vbn5v_12v 0 c=1.1807e-12
c777_3 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vbn5v_12v xdut.gnd_dsi c=2.08068e-13
cg773_116 xdut.xana.cldo_dsi<1> 0 c=2.97054e-12
c773_91 xdut.xana.cldo_dsi<1> xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.vh05ov c=1.60094e-15
c773_22 xdut.xana.cldo_dsi<1> xdut.xana.cldo_dsi<0> c=1.63045e-13
c773_21 xdut.xana.cldo_dsi<1> xdut.xana.vdd_uv_5v c=1.7533e-15
c773_20 xdut.xana.cldo_dsi<1> xdut.xana.net875 c=4.70257e-15
c773_19 xdut.xana.cldo_dsi<1> xdut.xana.irp10u<1> c=5.54253e-15
c773_18 xdut.xana.cldo_dsi<1> xdut.xana.ic5u<1> c=5.34566e-15
c773_6 xdut.xana.cldo_dsi<1> xdut.gnd_dsi c=3.83661e-12
c773_4 xdut.xana.cldo_dsi<1> xdut.xana.xdsi_ch1<1>.vsup_dsi c=1.74585e-12
c773_3 xdut.xana.cldo_dsi<1> xdut.cldo_p c=3.25061e-15
c773_2 xdut.xana.cldo_dsi<1> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=9.12112e-14
cg772_141 xdut.xana.cldo_dsi<0> 0 c=2.79343e-12
c772_109 xdut.xana.cldo_dsi<0> xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.vh05ov c=1.57952e-15
c772_21 xdut.xana.cldo_dsi<0> xdut.xana.vdd_uv_5v c=1.76004e-15
c772_20 xdut.xana.cldo_dsi<0> xdut.xana.net875 c=4.73184e-15
c772_19 xdut.xana.cldo_dsi<0> xdut.xana.irp10u<0> c=5.57346e-15
c772_18 xdut.xana.cldo_dsi<0> xdut.xana.ic5u<0> c=5.3766e-15
c772_6 xdut.xana.cldo_dsi<0> xdut.gnd_dsi c=3.60009e-12
c772_5 xdut.xana.cldo_dsi<0> xdut.xana.xdsi_ch1<0>.vsup_dsi c=1.74332e-12
c772_3 xdut.xana.cldo_dsi<0> xdut.cldo_p c=3.24717e-15
c772_2 xdut.xana.cldo_dsi<0> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=8.8147e-14
cg768_55 xdut.xana.ic5u<9> 0 c=2.69353e-14
c768_50 xdut.xana.ic5u<9> xdut.xana.xsup.xref.xiconst.a2 c=1.49398e-15
c768_28 xdut.xana.ic5u<9> xdut.xana.xldo.dm2 c=2.61996e-15
c768_25 xdut.xana.ic5u<9> xdut.xana.ic5u<8> c=1.12375e-13
c768_22 xdut.xana.ic5u<9> xdut.xana.ic5u<11> c=6.04568e-15
c768_21 xdut.xana.ic5u<9> xdut.xana.ic5u<10> c=3.97604e-15
c768_15 xdut.xana.ic5u<9> xdut.gndd_p c=2.39324e-14
c768_10 xdut.xana.ic5u<9> xdut.aout_int c=4.30814e-15
c768_8 xdut.xana.ic5u<9> xdut.xana.xldo.vlim c=1.61001e-14
c768_3 xdut.xana.ic5u<9> xdut.gnd_p c=2.08403e-13
c768_2 xdut.xana.ic5u<9> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=2.74218e-15
cg767_52 xdut.xana.ic5u<8> 0 c=4.47646e-14
c767_51 xdut.xana.ic5u<8> xdut.xana.xtmon.xtsens.net21 c=2.44124e-14
c767_31 xdut.xana.ic5u<8> xdut.xana.ibp5u<0> c=6.6246e-15
c767_29 xdut.xana.ic5u<8> xdut.xana.ic5u<10> c=3.94039e-15
c767_23 xdut.xana.ic5u<8> xdut.xana.ic5u<0> c=4.52826e-15
c767_22 xdut.xana.ic5u<8> xdut.gndd_p c=3.26589e-14
c767_12 xdut.xana.ic5u<8> xdut.aout_int c=5.26394e-15
c767_5 xdut.xana.ic5u<8> xdut.gnd_dsi c=9.21403e-15
c767_3 xdut.xana.ic5u<8> xdut.gnd_p c=2.49721e-13
c767_2 xdut.xana.ic5u<8> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=2.62679e-15
cg766_858 xdut.xana.vdd_uv_5v 0 c=1.02595e-13
c766_825 xdut.xana.vdd_uv_5v xdut.xana.xsup.xvddreg.xi37.p0 c=1.33648e-15
c766_656 xdut.xana.vdd_uv_5v xdut.xana.xdsi_ch1<1>.xtx.tx_data_5v<4> c=1.23946e-15
c766_393 xdut.xana.vdd_uv_5v xdut.xana.xdsi_ch1<0>.xtx.tx_data_5v<4> c=1.23931e-15
c766_146 xdut.xana.vdd_uv_5v xdut.xana.xsup.vrr_ok_5v c=1.02283e-15
c766_145 xdut.xana.vdd_uv_5v xdut.xana.ibp5u<0> c=4.02005e-15
c766_140 xdut.xana.vdd_uv_5v xdut.xana.net875 c=3.01062e-14
c766_139 xdut.xana.vdd_uv_5v xdut.xana.tielo c=2.21689e-15
c766_115 xdut.xana.vdd_uv_5v xdut.gndd_p c=1.43061e-13
c766_81 xdut.xana.vdd_uv_5v xdut.dsi_rx_txn<0> c=1.0567e-14
c766_80 xdut.xana.vdd_uv_5v xdut.dsi_ov<0> c=1.05455e-14
c766_78 xdut.xana.vdd_uv_5v xdut.atst_rx<0> c=1.09847e-15
c766_60 xdut.xana.vdd_uv_5v xdut.dsi_ov<1> c=1.05519e-14
c766_59 xdut.xana.vdd_uv_5v xdut.dsi_rx_txn<1> c=1.06e-14
c766_44 xdut.xana.vdd_uv_5v xdut.otp_vrr c=5.3725e-15
c766_40 xdut.xana.vdd_uv_5v xdut.ldo_en c=6.56043e-15
c766_31 xdut.xana.vdd_uv_5v xdut.vdd_rdiv_dis c=2.11212e-14
c766_30 xdut.xana.vdd_uv_5v xdut.vdd_iload_dis c=1.75211e-15
c766_17 xdut.xana.vdd_uv_5v xdut.aout_int c=1.62898e-14
c766_15 xdut.xana.vdd_uv_5v xdut.en_atb c=2.81616e-14
c766_14 xdut.xana.vdd_uv_5v xdut.atst_ts<1> c=1.16829e-15
c766_12 xdut.xana.vdd_uv_5v xdut.ot_error c=9.68087e-15
c766_10 xdut.xana.vdd_uv_5v xdut.atst_ts<0> c=1.17842e-14
c766_8 xdut.xana.vdd_uv_5v xdut.gnd_dsi c=1.30164e-13
c766_3 xdut.xana.vdd_uv_5v xdut.gnd_p c=3.5778e-13
c766_2 xdut.xana.vdd_uv_5v xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.16531e-13
cg765_47 xdut.xana.ibp5u<0> 0 c=3.18385e-14
c765_44 xdut.xana.ibp5u<0> xdut.xana.xtmon.net699 c=1.35829e-15
c765_37 xdut.xana.ibp5u<0> xdut.xana.xsup.xref.xbg.vbp_ibias c=1.20054e-15
c765_27 xdut.xana.ibp5u<0> xdut.xana.xsup.ibp10u<3> c=1.37807e-15
c765_26 xdut.xana.ibp5u<0> xdut.xana.xsup.xref.iaux10u c=1.99207e-14
c765_25 xdut.xana.ibp5u<0> xdut.xana.xsup.ibp5u<1> c=2.43997e-14
c765_21 xdut.xana.ibp5u<0> xdut.xana.ic5u<11> c=1.2083e-15
c765_20 xdut.xana.ibp5u<0> xdut.xana.ic5u<10> c=4.47211e-15
c765_11 xdut.xana.ibp5u<0> xdut.gndd_p c=4.67389e-14
c765_10 xdut.xana.ibp5u<0> xdut.otp_vrr c=5.79093e-15
c765_5 xdut.xana.ibp5u<0> xdut.gnd_dsi c=4.01231e-15
c765_3 xdut.xana.ibp5u<0> xdut.gnd_p c=4.07102e-13
c765_2 xdut.xana.ibp5u<0> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=2.50278e-15
cg763_121 xdut.xana.ic5u<10> 0 c=5.22694e-14
c763_111 xdut.xana.ic5u<10> xdut.xana.xsup.ic5u<12> c=3.65407e-15
c763_99 xdut.xana.ic5u<10> xdut.xana.ic5u<11> c=3.35569e-14
c763_94 xdut.xana.ic5u<10> xdut.xana.irp10u<0> c=1.83051e-15
c763_91 xdut.xana.ic5u<10> xdut.gndd_p c=4.27858e-14
c763_21 xdut.xana.ic5u<10> xdut.otp_vrr c=1.99132e-15
c763_7 xdut.xana.ic5u<10> xdut.aout_int c=5.6491e-15
c763_3 xdut.xana.ic5u<10> xdut.gnd_p c=5.0519e-13
c763_2 xdut.xana.ic5u<10> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.0524e-14
cg762_111 xdut.xana.vbg_buf 0 c=6.45834e-14
c762_110 xdut.xana.vbg_buf xdut.xana.xtmon.adj_ot_5v<0> c=1.25163e-15
c762_104 xdut.xana.vbg_buf xdut.xana.xtmon.adj_ot_5v<1> c=1.01336e-15
c762_102 xdut.xana.vbg_buf xdut.xana.xtmon.net740 c=3.06276e-15
c762_99 xdut.xana.vbg_buf xdut.xana.xtmon.net745 c=5.47203e-15
c762_97 xdut.xana.vbg_buf xdut.xana.xsup.xvrrmon.xcomp2.nn1 c=1.62881e-15
c762_94 xdut.xana.vbg_buf xdut.xana.xsup.xvrrmon.xcomp1.nn1 c=1.63798e-15
c762_92 xdut.xana.vbg_buf xdut.xana.xsup.xvrrmon.xcomp1.nn3 c=1.27399e-15
c762_91 xdut.xana.vbg_buf xdut.xana.xsup.xvrrmon.xcomp1.inp c=2.22821e-15
c762_82 xdut.xana.vbg_buf xdut.xana.xsup.xvrrmon.xcomp2.nn3 c=1.26891e-15
c762_81 xdut.xana.vbg_buf xdut.xana.xsup.xvrrmon.xcomp2.inp c=2.22813e-15
c762_75 xdut.xana.vbg_buf xdut.xana.xsup.xvbgbuf.net213 c=2.47038e-14
c762_74 xdut.xana.vbg_buf xdut.xana.xsup.xvbgbuf.vg_m5 c=2.9447e-14
c762_61 xdut.xana.vbg_buf xdut.xana.xsup.xvbgbuf.vcc_nbl c=2.32534e-15
c762_55 xdut.xana.vbg_buf xdut.xana.xldo.xvref.net30 c=6.18339e-15
c762_53 xdut.xana.vbg_buf xdut.xana.xldo.xvref.net34 c=7.54685e-15
c762_33 xdut.xana.vbg_buf xdut.gndd_p c=9.74298e-14
c762_12 xdut.xana.vbg_buf xdut.aout_int c=1.48865e-14
c762_5 xdut.xana.vbg_buf xdut.gnd_dsi c=1.52771e-14
c762_3 xdut.xana.vbg_buf xdut.gnd_p c=5.57923e-13
c762_2 xdut.xana.vbg_buf xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.42068e-14
cg758_44 xdut.xana.tielo 0 c=2.38357e-14
c758_37 xdut.xana.tielo xdut.gndd_p c=6.55137e-15
c758_35 xdut.xana.tielo xdut.atst_rx<0> c=1.00087e-14
c758_17 xdut.xana.tielo xdut.ldo_en c=4.35959e-14
c758_16 xdut.xana.tielo xdut.ldo_ok c=4.19655e-14
c758_13 xdut.xana.tielo xdut.en_atb c=1.74001e-15
c758_6 xdut.xana.tielo xdut.gnd_dsi c=8.94917e-15
c758_3 xdut.xana.tielo xdut.gnd_p c=3.74976e-15
c758_2 xdut.xana.tielo xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=5.10618e-15
c758_1 xdut.xana.tielo xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=2.75084e-15
cg738_107 xdut.xana.irp10u<1> 0 c=4.09495e-14
c738_98 xdut.xana.irp10u<1> xdut.xana.irp10u<2> c=1.70534e-15
c738_80 xdut.xana.irp10u<1> xdut.xana.xdsi_ch1<1>.xtx.xtx_imirror_0.vbint1<2> c=2.301e-15
c738_79 xdut.xana.irp10u<1> xdut.xana.xdsi_ch1<1>.xtx.xtx_imirror_0.vbint1<1> c=1.053e-15
c738_74 xdut.xana.irp10u<1> xdut.xana.xdsi_ch1<1>.xtx.xtx_imirror_0.vbnc c=7.22501e-15
c738_67 xdut.xana.irp10u<1> xdut.xana.xdsi_ch1<1>.xtx.net935 c=3.21613e-15
c738_65 xdut.xana.irp10u<1> xdut.xana.ic5u<5> c=1.25146e-13
c738_64 xdut.xana.irp10u<1> xdut.xana.ic5u<1> c=2.62629e-14
c738_63 xdut.xana.irp10u<1> xdut.xana.irp10u<0> c=1.50017e-15
c738_61 xdut.xana.irp10u<1> xdut.xana.ic5u<0> c=1.83991e-15
c738_60 xdut.xana.irp10u<1> xdut.gndd_p c=1.40213e-14
c738_4 xdut.xana.irp10u<1> xdut.gnd_dsi c=2.81689e-14
c738_3 xdut.xana.irp10u<1> xdut.gnd_p c=1.52634e-13
c738_2 xdut.xana.irp10u<1> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=5.1962e-15
cg737_117 xdut.xana.ic5u<5> 0 c=4.36337e-14
c737_89 xdut.xana.ic5u<5> xdut.xana.ic5u<1> c=1.25548e-13
c737_85 xdut.xana.ic5u<5> xdut.gndd_p c=8.86323e-15
c737_7 xdut.xana.ic5u<5> xdut.xana.xdsi_ch1<1>.xrx.xrec_th.offs_sw_d c=1.11662e-14
c737_6 xdut.xana.ic5u<5> xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd c=2.15891e-15
c737_4 xdut.xana.ic5u<5> xdut.gnd_dsi c=2.3617e-14
c737_3 xdut.xana.ic5u<5> xdut.gnd_p c=9.32778e-14
c737_2 xdut.xana.ic5u<5> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=9.79167e-15
cg736_90 xdut.xana.ic5u<1> 0 c=3.35071e-14
c736_85 xdut.xana.ic5u<1> xdut.xana.xsup.xref.xiconst.a2 c=2.44921e-15
c736_74 xdut.xana.ic5u<1> xdut.xana.ic5u<6> c=2.26029e-15
c736_64 xdut.xana.ic5u<1> xdut.xana.irp10u<0> c=4.50823e-15
c736_62 xdut.xana.ic5u<1> xdut.xana.ic5u<0> c=2.81488e-15
c736_61 xdut.xana.ic5u<1> xdut.gndd_p c=8.54247e-15
c736_16 xdut.xana.ic5u<1> xdut.otp_vrr c=2.14713e-15
c736_4 xdut.xana.ic5u<1> xdut.gnd_dsi c=2.02669e-14
c736_3 xdut.xana.ic5u<1> xdut.gnd_p c=1.61103e-13
c736_2 xdut.xana.ic5u<1> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=7.78266e-15
cg735_103 xdut.xana.irp10u<0> 0 c=4.51894e-14
c735_73 xdut.xana.irp10u<0> xdut.xana.xdsi_ch1<0>.xtx.tx_cfg_5v<1> c=2.14437e-15
c735_66 xdut.xana.irp10u<0> xdut.xana.xdsi_ch1<0>.xtx.vdsi_ctrl_5v<0> c=3.13367e-15
c735_62 xdut.xana.irp10u<0> xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.vbint1<2> c=2.30312e-15
c735_61 xdut.xana.irp10u<0> xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.vbint1<1> c=1.06069e-15
c735_56 xdut.xana.irp10u<0> xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.vbnc c=7.22043e-15
c735_48 xdut.xana.irp10u<0> xdut.xana.xdsi_ch1<0>.xtx.net935 c=3.216e-15
c735_44 xdut.xana.irp10u<0> xdut.xana.ic5u<4> c=8.02784e-14
c735_43 xdut.xana.irp10u<0> xdut.xana.ic5u<0> c=3.58386e-14
c735_42 xdut.xana.irp10u<0> xdut.gndd_p c=1.0261e-14
c735_4 xdut.xana.irp10u<0> xdut.gnd_dsi c=2.80878e-14
c735_3 xdut.xana.irp10u<0> xdut.gnd_p c=1.495e-13
c735_2 xdut.xana.irp10u<0> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=5.97193e-15
cg734_44 xdut.xana.ic5u<4> 0 c=1.86354e-14
c734_22 xdut.xana.ic5u<4> xdut.xana.ic5u<0> c=8.16306e-14
c734_21 xdut.xana.ic5u<4> xdut.gndd_p c=1.20566e-14
c734_7 xdut.xana.ic5u<4> xdut.xana.xdsi_ch1<0>.xrx.xrec_th.offs_sw_d c=1.1166e-14
c734_5 xdut.xana.ic5u<4> xdut.gnd_dsi c=2.34983e-14
c734_4 xdut.xana.ic5u<4> xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd c=2.14625e-15
c734_3 xdut.xana.ic5u<4> xdut.gnd_p c=3.04543e-14
c734_2 xdut.xana.ic5u<4> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=4.1266e-15
cg733_92 xdut.xana.ic5u<0> 0 c=3.23459e-14
c733_82 xdut.xana.ic5u<0> xdut.xana.xsup.xref.xiconst.a2 c=2.52022e-15
c733_57 xdut.xana.ic5u<0> xdut.xana.xdsi_ch1<0>.xtx.tx_cfg_5v<1> c=1.98824e-15
c733_42 xdut.xana.ic5u<0> xdut.gndd_p c=1.07855e-14
c733_4 xdut.xana.ic5u<0> xdut.gnd_dsi c=2.02716e-14
c733_3 xdut.xana.ic5u<0> xdut.gnd_p c=1.56381e-13
c733_2 xdut.xana.ic5u<0> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=8.88822e-15
c671_8 xdut.xpad18.gpstrong xdut.xpad18.gpweak c=2.80286e-15
c671_5 xdut.xpad18.gpstrong xdut.xpad18.dsb_ls c=1.14362e-15
c671_3 xdut.xpad18.gpstrong xdut.rfc_p c=1.99344e-14
c671_2 xdut.xpad18.gpstrong xdut.dgnd_p c=1.75809e-15
c671_1 xdut.xpad18.gpstrong xdut.vio_p c=4.48277e-14
c670_10 xdut.xpad18.gnstrong xdut.xpad18.gnweak c=1.60646e-15
c670_6 xdut.xpad18.gnstrong xdut.xpad18.ds_ls c=1.44776e-15
c670_4 xdut.xpad18.gnstrong xdut.gndd_p c=1.22748e-15
c670_3 xdut.xpad18.gnstrong xdut.rfc_p c=6.27404e-15
c670_2 xdut.xpad18.gnstrong xdut.dgnd_p c=1.85769e-14
c670_1 xdut.xpad18.gnstrong xdut.vio_p c=3.79368e-15
c669_12 xdut.xpad18.gnweak xdut.xpad18.gpweak c=7.48301e-15
c669_10 xdut.xpad18.gnweak xdut.xpad18.gn c=1.46143e-15
c669_5 xdut.xpad18.gnweak xdut.gndd_p c=1.6201e-15
c669_3 xdut.xpad18.gnweak xdut.rfc_p c=2.35103e-15
c669_2 xdut.xpad18.gnweak xdut.dgnd_p c=1.09069e-14
c669_1 xdut.xpad18.gnweak xdut.vio_p c=1.1176e-14
c668_7 xdut.xpad18.gpweak xdut.xpad18.gp c=1.50014e-15
c668_4 xdut.xpad18.gpweak xdut.gndd_p c=1.61826e-15
c668_3 xdut.xpad18.gpweak xdut.rfc_p c=7.44771e-15
c668_2 xdut.xpad18.gpweak xdut.dgnd_p c=5.24336e-15
c668_1 xdut.xpad18.gpweak xdut.vio_p c=2.04845e-14
c666_3 xdut.xpad18.gn xdut.gndd_p c=1.4188e-15
c666_1 xdut.xpad18.gn xdut.vio_p c=1.69757e-15
c665_8 xdut.xpad18.xlsgn.o1b xdut.xpad18.xlsgn.o1 c=1.43632e-15
c665_2 xdut.xpad18.xlsgn.o1b xdut.gndd_p c=1.44838e-15
c665_1 xdut.xpad18.xlsgn.o1b xdut.vio_p c=1.08795e-15
c664_2 xdut.xpad18.xlsgn.o1 xdut.gndd_p c=1.79407e-15
c660_8 xdut.xpad18.gp xdut.xpad18.xlsgp.o1b c=1.50345e-15
c660_3 xdut.xpad18.gp xdut.gndd_p c=2.38283e-15
c660_1 xdut.xpad18.gp xdut.vio_p c=1.86983e-15
c659_2 xdut.xpad18.ds_ls xdut.gndd_p c=4.57694e-15
c659_1 xdut.xpad18.ds_ls xdut.vio_p c=1.5133e-15
c658_3 xdut.xpad18.dsb_ls xdut.gndd_p c=2.94449e-15
c658_1 xdut.xpad18.dsb_ls xdut.vio_p c=3.4162e-15
c652_25 xdut.xpad1.aoutbb xdut.xpad1.cb c=1.15406e-15
c652_20 xdut.xpad1.aoutbb xdut.xpad1.aoutb c=1.26903e-15
c652_9 xdut.xpad1.aoutbb xdut.xpad1.ie_ls c=2.05908e-15
c652_5 xdut.xpad1.aoutbb xdut.gndd_p c=5.20438e-15
c652_1 xdut.xpad1.aoutbb xdut.vio_p c=1.19508e-15
c642_16 xdut.xpad1.ie_ls xdut.xpad1.aoutb c=1.79858e-15
c642_3 xdut.xpad1.ie_ls xdut.gndd_p c=2.78689e-15
c642_1 xdut.xpad1.ie_ls xdut.vio_p c=1.77064e-15
c640_3 xdut.xpad1.xlsie.o1b xdut.xpad1.xlsie.o1 c=1.47326e-15
c640_2 xdut.xpad1.xlsie.o1b xdut.gndd_p c=1.51067e-15
c640_1 xdut.xpad1.xlsie.o1b xdut.vio_p c=1.10798e-15
c639_2 xdut.xpad1.xlsie.o1 xdut.gndd_p c=2.14176e-15
c639_1 xdut.xpad1.xlsie.o1 xdut.vio_p c=1.01709e-15
cg624_3076 xdut.gndd_p 0 c=9.21204e-11
c624_3075 xdut.gndd_p xdut.xpad5_vcc.net021 c=9.5699e-15
c624_3074 xdut.gndd_p xdut.xpad5_vcc.net_0 c=3.4042e-14
c624_3073 xdut.gndd_p xdut.xpad3_vdd.net_1 c=5.57761e-14
c624_3072 xdut.gndd_p xdut.xpad3_vdd.net_0 c=3.92182e-14
c624_3070 xdut.gndd_p xdut.xpad24.xggp.o1 c=1.15972e-15
c624_3069 xdut.gndd_p xdut.xpad24.ib c=1.45182e-15
c624_3067 xdut.gndd_p xdut.xpad24.i1b c=2.47874e-15
c624_3066 xdut.gndd_p xdut.xpad24.i1 c=2.26646e-15
c624_3065 xdut.gndd_p xdut.xpad24.dsbb c=2.28492e-15
c624_3064 xdut.gndd_p xdut.xpad24.dsb c=2.67816e-15
c624_3063 xdut.gndd_p xdut.xpad24.ieb c=2.66173e-15
c624_3062 xdut.gndd_p xdut.xpad24.cb c=3.06787e-15
c624_3061 xdut.gndd_p xdut.xpad24.iebb c=2.35685e-15
c624_3060 xdut.gndd_p xdut.xpad24.pdb c=3.31718e-15
c624_3059 xdut.gndd_p xdut.xpad24.pdbb c=2.75912e-15
c624_3057 xdut.gndd_p xdut.xpad24.xgpull.o1 c=1.24905e-15
c624_3056 xdut.gndd_p xdut.xpad24.pub c=1.25277e-15
c624_3054 xdut.gndd_p xdut.xpad24.xgpull.net96 c=2.37515e-15
c624_3053 xdut.gndd_p xdut.xpad24.pull c=2.31468e-15
c624_3042 xdut.gndd_p xdut.xpad24.xlsds.d3 c=1.51774e-15
c624_3041 xdut.gndd_p xdut.xpad24.xlsie.d3 c=1.26632e-15
c624_3031 xdut.gndd_p xdut.xpad24.oeb c=2.19837e-15
c624_3030 xdut.gndd_p xdut.xpad24.oebb c=1.06997e-15
c624_3028 xdut.gndd_p xdut.xpad24.xggn.o1 c=1.14042e-15
c624_3027 xdut.gndd_p xdut.xpad24.i2b c=2.44429e-15
c624_3026 xdut.gndd_p xdut.xpad24.i2 c=2.29061e-15
c624_3023 xdut.gndd_p xdut.xpad23.xggp.o1 c=1.16087e-15
c624_3022 xdut.gndd_p xdut.xpad23.ib c=1.45185e-15
c624_3020 xdut.gndd_p xdut.xpad23.i1b c=2.47934e-15
c624_3019 xdut.gndd_p xdut.xpad23.i1 c=2.26653e-15
c624_3018 xdut.gndd_p xdut.xpad23.dsbb c=2.28493e-15
c624_3017 xdut.gndd_p xdut.xpad23.dsb c=2.67847e-15
c624_3016 xdut.gndd_p xdut.xpad23.ieb c=2.65207e-15
c624_3015 xdut.gndd_p xdut.xpad23.cb c=3.05805e-15
c624_3014 xdut.gndd_p xdut.xpad23.iebb c=2.36757e-15
c624_3013 xdut.gndd_p xdut.xpad23.pdb c=3.31853e-15
c624_3012 xdut.gndd_p xdut.xpad23.pdbb c=2.74928e-15
c624_3010 xdut.gndd_p xdut.xpad23.xgpull.o1 c=1.25316e-15
c624_3009 xdut.gndd_p xdut.xpad23.pub c=1.25634e-15
c624_3007 xdut.gndd_p xdut.xpad23.xgpull.net96 c=2.38055e-15
c624_3006 xdut.gndd_p xdut.xpad23.pull c=2.31825e-15
c624_2995 xdut.gndd_p xdut.xpad23.xlsds.d3 c=1.5179e-15
c624_2994 xdut.gndd_p xdut.xpad23.xlsie.d3 c=1.26284e-15
c624_2984 xdut.gndd_p xdut.xpad23.oeb c=2.19457e-15
c624_2983 xdut.gndd_p xdut.xpad23.oebb c=1.06999e-15
c624_2981 xdut.gndd_p xdut.xpad23.xggn.o1 c=1.14042e-15
c624_2980 xdut.gndd_p xdut.xpad23.i2b c=2.44496e-15
c624_2979 xdut.gndd_p xdut.xpad23.i2 c=2.28554e-15
c624_2976 xdut.gndd_p xdut.xpad22.xggp.o1 c=1.15675e-15
c624_2975 xdut.gndd_p xdut.xpad22.ib c=1.45185e-15
c624_2973 xdut.gndd_p xdut.xpad22.i1b c=2.47934e-15
c624_2972 xdut.gndd_p xdut.xpad22.i1 c=2.26653e-15
c624_2971 xdut.gndd_p xdut.xpad22.dsbb c=2.28492e-15
c624_2970 xdut.gndd_p xdut.xpad22.dsb c=2.67855e-15
c624_2969 xdut.gndd_p xdut.xpad22.ieb c=2.65661e-15
c624_2968 xdut.gndd_p xdut.xpad22.cb c=3.05805e-15
c624_2967 xdut.gndd_p xdut.xpad22.iebb c=2.36758e-15
c624_2966 xdut.gndd_p xdut.xpad22.pdb c=3.31853e-15
c624_2965 xdut.gndd_p xdut.xpad22.pdbb c=2.74928e-15
c624_2963 xdut.gndd_p xdut.xpad22.xgpull.o1 c=1.25419e-15
c624_2962 xdut.gndd_p xdut.xpad22.pub c=1.25633e-15
c624_2960 xdut.gndd_p xdut.xpad22.xgpull.net96 c=2.38055e-15
c624_2959 xdut.gndd_p xdut.xpad22.pull c=2.31826e-15
c624_2948 xdut.gndd_p xdut.xpad22.xlsds.d3 c=1.5179e-15
c624_2947 xdut.gndd_p xdut.xpad22.xlsie.d3 c=1.26284e-15
c624_2937 xdut.gndd_p xdut.xpad22.oeb c=2.19814e-15
c624_2936 xdut.gndd_p xdut.xpad22.oebb c=1.06998e-15
c624_2934 xdut.gndd_p xdut.xpad22.xggn.o1 c=1.14042e-15
c624_2933 xdut.gndd_p xdut.xpad22.i2b c=2.44496e-15
c624_2932 xdut.gndd_p xdut.xpad22.i2 c=2.28554e-15
c624_2929 xdut.gndd_p xdut.xpad21.xggp.o1 c=1.15675e-15
c624_2928 xdut.gndd_p xdut.xpad21.ib c=1.4513e-15
c624_2926 xdut.gndd_p xdut.xpad21.i1b c=2.47816e-15
c624_2925 xdut.gndd_p xdut.xpad21.i1 c=2.26654e-15
c624_2924 xdut.gndd_p xdut.xpad21.dsbb c=2.28493e-15
c624_2923 xdut.gndd_p xdut.xpad21.dsb c=2.6776e-15
c624_2922 xdut.gndd_p xdut.xpad21.ieb c=2.65159e-15
c624_2921 xdut.gndd_p xdut.xpad21.cb c=3.05821e-15
c624_2920 xdut.gndd_p xdut.xpad21.iebb c=2.3676e-15
c624_2919 xdut.gndd_p xdut.xpad21.pdb c=3.31805e-15
c624_2918 xdut.gndd_p xdut.xpad21.pdbb c=2.74928e-15
c624_2916 xdut.gndd_p xdut.xpad21.xgpull.o1 c=1.25195e-15
c624_2915 xdut.gndd_p xdut.xpad21.pub c=1.25599e-15
c624_2913 xdut.gndd_p xdut.xpad21.xgpull.net96 c=2.38056e-15
c624_2912 xdut.gndd_p xdut.xpad21.pull c=2.31827e-15
c624_2901 xdut.gndd_p xdut.xpad21.xlsds.d3 c=1.51799e-15
c624_2900 xdut.gndd_p xdut.xpad21.xlsie.d3 c=1.26284e-15
c624_2890 xdut.gndd_p xdut.xpad21.oeb c=2.19814e-15
c624_2889 xdut.gndd_p xdut.xpad21.oebb c=1.06998e-15
c624_2887 xdut.gndd_p xdut.xpad21.xggn.o1 c=1.14044e-15
c624_2886 xdut.gndd_p xdut.xpad21.i2b c=2.44496e-15
c624_2885 xdut.gndd_p xdut.xpad21.i2 c=2.28554e-15
c624_2882 xdut.gndd_p xdut.xpad2.xggp.o1 c=1.15946e-15
c624_2881 xdut.gndd_p xdut.xpad2.ib c=2.2308e-15
c624_2879 xdut.gndd_p xdut.xpad2.i1b c=2.48373e-15
c624_2878 xdut.gndd_p xdut.xpad2.i1 c=2.27927e-15
c624_2877 xdut.gndd_p xdut.xpad2.dsbb c=2.58604e-15
c624_2876 xdut.gndd_p xdut.xpad2.dsb c=3.68247e-15
c624_2875 xdut.gndd_p xdut.xpad2.ieb c=2.67613e-15
c624_2874 xdut.gndd_p xdut.xpad2.cb c=3.06143e-15
c624_2873 xdut.gndd_p xdut.xpad2.iebb c=2.38802e-15
c624_2872 xdut.gndd_p xdut.xpad2.pdb c=3.35613e-15
c624_2871 xdut.gndd_p xdut.xpad2.pdbb c=2.7901e-15
c624_2869 xdut.gndd_p xdut.xpad2.xgpull.o1 c=1.26278e-15
c624_2868 xdut.gndd_p xdut.xpad2.pub c=2.05174e-15
c624_2866 xdut.gndd_p xdut.xpad2.xgpull.net96 c=2.3946e-15
c624_2865 xdut.gndd_p xdut.xpad2.pull c=2.3174e-15
c624_2854 xdut.gndd_p xdut.xpad2.xlsds.d3 c=1.51857e-15
c624_2853 xdut.gndd_p xdut.xpad2.xlsie.d3 c=1.2636e-15
c624_2843 xdut.gndd_p xdut.xpad2.oeb c=2.99067e-15
c624_2842 xdut.gndd_p xdut.xpad2.oebb c=1.09389e-15
c624_2840 xdut.gndd_p xdut.xpad2.xggn.o1 c=1.14162e-15
c624_2839 xdut.gndd_p xdut.xpad2.i2b c=2.45227e-15
c624_2838 xdut.gndd_p xdut.xpad2.i2 c=2.30178e-15
c624_2835 xdut.gndd_p xdut.xpad18.xggp.o1 c=1.16512e-15
c624_2834 xdut.gndd_p xdut.xpad18.ib c=1.43674e-15
c624_2832 xdut.gndd_p xdut.xpad18.i1b c=2.47309e-15
c624_2831 xdut.gndd_p xdut.xpad18.i1 c=2.26873e-15
c624_2830 xdut.gndd_p xdut.xpad18.dsbb c=2.2941e-15
c624_2829 xdut.gndd_p xdut.xpad18.dsb c=2.67502e-15
c624_2828 xdut.gndd_p xdut.xpad18.ieb c=2.67629e-15
c624_2827 xdut.gndd_p xdut.xpad18.cb c=3.05989e-15
c624_2826 xdut.gndd_p xdut.xpad18.iebb c=2.38154e-15
c624_2825 xdut.gndd_p xdut.xpad18.pdb c=3.34154e-15
c624_2824 xdut.gndd_p xdut.xpad18.pdbb c=2.76991e-15
c624_2822 xdut.gndd_p xdut.xpad18.xgpull.o1 c=1.2524e-15
c624_2821 xdut.gndd_p xdut.xpad18.pub c=1.25485e-15
c624_2819 xdut.gndd_p xdut.xpad18.xgpull.net96 c=2.38719e-15
c624_2818 xdut.gndd_p xdut.xpad18.pull c=2.30538e-15
c624_2808 xdut.gndd_p xdut.xpad18.xlsds.d3 c=1.52634e-15
c624_2807 xdut.gndd_p xdut.xpad18.xlsie.d3 c=1.26056e-15
c624_2797 xdut.gndd_p xdut.xpad18.xggn.o1 c=1.13195e-15
c624_2796 xdut.gndd_p xdut.xpad18.i2b c=2.43376e-15
c624_2793 xdut.gndd_p xdut.xpad17.xggp.o1 c=1.16587e-15
c624_2792 xdut.gndd_p xdut.xpad17.ib c=1.45702e-15
c624_2790 xdut.gndd_p xdut.xpad17.i1b c=2.4775e-15
c624_2789 xdut.gndd_p xdut.xpad17.i1 c=2.27238e-15
c624_2788 xdut.gndd_p xdut.xpad17.dsbb c=2.2935e-15
c624_2787 xdut.gndd_p xdut.xpad17.dsb c=2.68659e-15
c624_2786 xdut.gndd_p xdut.xpad17.ieb c=2.68032e-15
c624_2785 xdut.gndd_p xdut.xpad17.cb c=3.07726e-15
c624_2784 xdut.gndd_p xdut.xpad17.iebb c=2.38266e-15
c624_2783 xdut.gndd_p xdut.xpad17.pdb c=3.34721e-15
c624_2782 xdut.gndd_p xdut.xpad17.pdbb c=2.78118e-15
c624_2780 xdut.gndd_p xdut.xpad17.xgpull.o1 c=1.25768e-15
c624_2779 xdut.gndd_p xdut.xpad17.pub c=1.27212e-15
c624_2777 xdut.gndd_p xdut.xpad17.xgpull.net96 c=2.38928e-15
c624_2776 xdut.gndd_p xdut.xpad17.pull c=2.30657e-15
c624_2765 xdut.gndd_p xdut.xpad17.xlsds.d3 c=1.5264e-15
c624_2764 xdut.gndd_p xdut.xpad17.xlsie.d3 c=1.26028e-15
c624_2754 xdut.gndd_p xdut.xpad17.oeb c=2.22944e-15
c624_2753 xdut.gndd_p xdut.xpad17.oebb c=1.0884e-15
c624_2751 xdut.gndd_p xdut.xpad17.xggn.o1 c=1.13601e-15
c624_2750 xdut.gndd_p xdut.xpad17.i2b c=2.4563e-15
c624_2749 xdut.gndd_p xdut.xpad17.i2 c=2.29157e-15
c624_2746 xdut.gndd_p xdut.xpad16.xggp.o1 c=1.16593e-15
c624_2745 xdut.gndd_p xdut.xpad16.ib c=1.45702e-15
c624_2743 xdut.gndd_p xdut.xpad16.i1b c=2.4775e-15
c624_2742 xdut.gndd_p xdut.xpad16.i1 c=2.2724e-15
c624_2741 xdut.gndd_p xdut.xpad16.dsbb c=2.2935e-15
c624_2740 xdut.gndd_p xdut.xpad16.dsb c=2.68659e-15
c624_2739 xdut.gndd_p xdut.xpad16.ieb c=2.68026e-15
c624_2738 xdut.gndd_p xdut.xpad16.cb c=3.07785e-15
c624_2737 xdut.gndd_p xdut.xpad16.iebb c=2.38265e-15
c624_2736 xdut.gndd_p xdut.xpad16.pdb c=3.34767e-15
c624_2735 xdut.gndd_p xdut.xpad16.pdbb c=2.78118e-15
c624_2733 xdut.gndd_p xdut.xpad16.xgpull.o1 c=1.25768e-15
c624_2732 xdut.gndd_p xdut.xpad16.pub c=1.26997e-15
c624_2730 xdut.gndd_p xdut.xpad16.xgpull.net96 c=2.38756e-15
c624_2729 xdut.gndd_p xdut.xpad16.pull c=2.30657e-15
c624_2718 xdut.gndd_p xdut.xpad16.xlsds.d3 c=1.5264e-15
c624_2717 xdut.gndd_p xdut.xpad16.xlsie.d3 c=1.26028e-15
c624_2707 xdut.gndd_p xdut.xpad16.oeb c=2.22971e-15
c624_2706 xdut.gndd_p xdut.xpad16.oebb c=1.0884e-15
c624_2704 xdut.gndd_p xdut.xpad16.xggn.o1 c=1.13601e-15
c624_2703 xdut.gndd_p xdut.xpad16.i2b c=2.45494e-15
c624_2702 xdut.gndd_p xdut.xpad16.i2 c=2.29157e-15
c624_2699 xdut.gndd_p xdut.xpad15.xggp.o1 c=1.16589e-15
c624_2698 xdut.gndd_p xdut.xpad15.ib c=2.23007e-15
c624_2696 xdut.gndd_p xdut.xpad15.i1b c=2.47738e-15
c624_2695 xdut.gndd_p xdut.xpad15.i1 c=2.27558e-15
c624_2694 xdut.gndd_p xdut.xpad15.dsbb c=2.57052e-15
c624_2693 xdut.gndd_p xdut.xpad15.dsb c=2.69207e-15
c624_2692 xdut.gndd_p xdut.xpad15.ieb c=2.68031e-15
c624_2691 xdut.gndd_p xdut.xpad15.cb c=3.07633e-15
c624_2690 xdut.gndd_p xdut.xpad15.iebb c=2.38104e-15
c624_2689 xdut.gndd_p xdut.xpad15.pdb c=4.37287e-15
c624_2688 xdut.gndd_p xdut.xpad15.pdbb c=2.82071e-15
c624_2686 xdut.gndd_p xdut.xpad15.xgpull.o1 c=1.28263e-15
c624_2685 xdut.gndd_p xdut.xpad15.pub c=1.31848e-15
c624_2683 xdut.gndd_p xdut.xpad15.xgpull.net96 c=2.38919e-15
c624_2682 xdut.gndd_p xdut.xpad15.pull c=2.30657e-15
c624_2671 xdut.gndd_p xdut.xpad15.xlsds.d3 c=1.5264e-15
c624_2670 xdut.gndd_p xdut.xpad15.xlsie.d3 c=1.26019e-15
c624_2660 xdut.gndd_p xdut.xpad15.oeb c=3.00346e-15
c624_2659 xdut.gndd_p xdut.xpad15.oebb c=1.09524e-15
c624_2657 xdut.gndd_p xdut.xpad15.xggn.o1 c=1.13602e-15
c624_2656 xdut.gndd_p xdut.xpad15.i2b c=2.45602e-15
c624_2655 xdut.gndd_p xdut.xpad15.i2 c=2.29476e-15
c624_2652 xdut.gndd_p xdut.xpad14.xggp.o1 c=1.16589e-15
c624_2651 xdut.gndd_p xdut.xpad14.ib c=1.45977e-15
c624_2649 xdut.gndd_p xdut.xpad14.i1b c=2.47738e-15
c624_2648 xdut.gndd_p xdut.xpad14.i1 c=2.27238e-15
c624_2647 xdut.gndd_p xdut.xpad14.dsbb c=2.29347e-15
c624_2646 xdut.gndd_p xdut.xpad14.dsb c=2.68658e-15
c624_2645 xdut.gndd_p xdut.xpad14.ieb c=2.68033e-15
c624_2644 xdut.gndd_p xdut.xpad14.cb c=3.0763e-15
c624_2643 xdut.gndd_p xdut.xpad14.iebb c=2.38266e-15
c624_2642 xdut.gndd_p xdut.xpad14.pdb c=3.34727e-15
c624_2641 xdut.gndd_p xdut.xpad14.pdbb c=2.78131e-15
c624_2639 xdut.gndd_p xdut.xpad14.xgpull.o1 c=1.25768e-15
c624_2638 xdut.gndd_p xdut.xpad14.pub c=1.27019e-15
c624_2636 xdut.gndd_p xdut.xpad14.xgpull.net96 c=2.38918e-15
c624_2635 xdut.gndd_p xdut.xpad14.pull c=2.30657e-15
c624_2624 xdut.gndd_p xdut.xpad14.xlsds.d3 c=1.5264e-15
c624_2623 xdut.gndd_p xdut.xpad14.xlsie.d3 c=1.26019e-15
c624_2613 xdut.gndd_p xdut.xpad14.oeb c=2.23032e-15
c624_2612 xdut.gndd_p xdut.xpad14.oebb c=1.08843e-15
c624_2610 xdut.gndd_p xdut.xpad14.xggn.o1 c=1.13595e-15
c624_2609 xdut.gndd_p xdut.xpad14.i2b c=2.45482e-15
c624_2608 xdut.gndd_p xdut.xpad14.i2 c=2.29157e-15
c624_2605 xdut.gndd_p xdut.xpad13.xggp.o1 c=1.16598e-15
c624_2604 xdut.gndd_p xdut.xpad13.ib c=1.45702e-15
c624_2602 xdut.gndd_p xdut.xpad13.i1b c=2.47785e-15
c624_2601 xdut.gndd_p xdut.xpad13.i1 c=2.27239e-15
c624_2600 xdut.gndd_p xdut.xpad13.dsbb c=2.29347e-15
c624_2599 xdut.gndd_p xdut.xpad13.dsb c=2.69257e-15
c624_2598 xdut.gndd_p xdut.xpad13.ieb c=2.68033e-15
c624_2597 xdut.gndd_p xdut.xpad13.cb c=3.07633e-15
c624_2596 xdut.gndd_p xdut.xpad13.iebb c=2.38264e-15
c624_2595 xdut.gndd_p xdut.xpad13.pdb c=3.34728e-15
c624_2594 xdut.gndd_p xdut.xpad13.pdbb c=2.78117e-15
c624_2592 xdut.gndd_p xdut.xpad13.xgpull.o1 c=1.25768e-15
c624_2591 xdut.gndd_p xdut.xpad13.pub c=1.26999e-15
c624_2589 xdut.gndd_p xdut.xpad13.xgpull.net96 c=2.38919e-15
c624_2588 xdut.gndd_p xdut.xpad13.pull c=2.30657e-15
c624_2577 xdut.gndd_p xdut.xpad13.xlsds.d3 c=1.5264e-15
c624_2576 xdut.gndd_p xdut.xpad13.xlsie.d3 c=1.26019e-15
c624_2566 xdut.gndd_p xdut.xpad13.oeb c=2.23113e-15
c624_2565 xdut.gndd_p xdut.xpad13.oebb c=1.08839e-15
c624_2563 xdut.gndd_p xdut.xpad13.xggn.o1 c=1.14072e-15
c624_2562 xdut.gndd_p xdut.xpad13.i2b c=2.45482e-15
c624_2561 xdut.gndd_p xdut.xpad13.i2 c=2.29157e-15
c624_2559 xdut.gndd_p xdut.xpad1.xggp.o1 c=1.15521e-15
c624_2558 xdut.gndd_p xdut.xpad1.ib c=1.45161e-15
c624_2556 xdut.gndd_p xdut.xpad1.i1b c=2.48247e-15
c624_2555 xdut.gndd_p xdut.xpad1.i1 c=2.27478e-15
c624_2554 xdut.gndd_p xdut.xpad1.dsbb c=2.28639e-15
c624_2553 xdut.gndd_p xdut.xpad1.dsb c=2.67942e-15
c624_2552 xdut.gndd_p xdut.xpad1.cb c=3.04438e-15
c624_2551 xdut.gndd_p xdut.xpad1.pdb c=3.33629e-15
c624_2550 xdut.gndd_p xdut.xpad1.pdbb c=2.75454e-15
c624_2548 xdut.gndd_p xdut.xpad1.xgpull.o1 c=1.25399e-15
c624_2547 xdut.gndd_p xdut.xpad1.pub c=1.26663e-15
c624_2545 xdut.gndd_p xdut.xpad1.xgpull.net96 c=2.3981e-15
c624_2544 xdut.gndd_p xdut.xpad1.pull c=2.34051e-15
c624_2533 xdut.gndd_p xdut.xpad1.xlsds.d3 c=1.5226e-15
c624_2532 xdut.gndd_p xdut.xpad1.xlsie.d2 c=1.25681e-15
c624_2523 xdut.gndd_p xdut.xpad1.oeb c=2.21583e-15
c624_2522 xdut.gndd_p xdut.xpad1.oebb c=1.08915e-15
c624_2520 xdut.gndd_p xdut.xpad1.xggn.o1 c=1.13577e-15
c624_2519 xdut.gndd_p xdut.xpad1.i2b c=2.45064e-15
c624_2518 xdut.gndd_p xdut.xpad1.i2 c=2.29632e-15
c624_2475 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.vtailn c=2.90515e-15
c624_2474 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.netm27m28 c=1.21539e-15
c624_2452 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net1531 c=1.22822e-13
c624_2448 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.stdby c=9.98189e-15
c624_2443 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_85 c=1.6911e-15
c624_2442 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_84 c=1.75352e-15
c624_2441 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_83 c=1.7693e-15
c624_2440 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_82 c=1.75506e-15
c624_2439 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_81 c=1.76558e-15
c624_2438 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_80 c=1.75321e-15
c624_2437 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_79 c=1.76994e-15
c624_2436 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_78 c=1.7592e-15
c624_2435 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_77 c=1.76663e-15
c624_2434 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_76 c=1.75999e-15
c624_2433 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_75 c=1.76711e-15
c624_2432 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_74 c=1.76123e-15
c624_2431 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_73 c=1.76724e-15
c624_2430 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_72 c=1.75622e-15
c624_2429 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_71 c=1.76125e-15
c624_2428 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_70 c=1.76124e-15
c624_2427 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_69 c=1.76238e-15
c624_2426 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_68 c=1.7545e-15
c624_2425 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_67 c=1.76043e-15
c624_2424 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_66 c=1.75907e-15
c624_2423 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_65 c=1.75858e-15
c624_2422 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_64 c=1.75241e-15
c624_2421 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_63 c=1.75796e-15
c624_2420 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_62 c=1.75488e-15
c624_2419 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_61 c=1.74801e-15
c624_2418 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_60 c=1.7555e-15
c624_2417 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.vi_0.n_59 c=1.77841e-15
c624_2416 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xvi_0.net229 c=3.30667e-14
c624_2415 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xvi_0.net172 c=1.2361e-14
c624_2379 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_88 c=3.07537e-15
c624_2378 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_87 c=3.43324e-15
c624_2377 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_86 c=3.2597e-15
c624_2376 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_85 c=3.0793e-15
c624_2375 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_84 c=3.24813e-15
c624_2374 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_83 c=3.05263e-15
c624_2373 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_82 c=3.2473e-15
c624_2372 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_81 c=3.05958e-15
c624_2371 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_80 c=3.26235e-15
c624_2370 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_79 c=3.06453e-15
c624_2369 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_78 c=3.26088e-15
c624_2368 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_77 c=3.07391e-15
c624_2367 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_76 c=3.26876e-15
c624_2366 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_75 c=3.07111e-15
c624_2365 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_74 c=3.26777e-15
c624_2364 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_73 c=3.08158e-15
c624_2363 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_72 c=3.27226e-15
c624_2362 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_71 c=3.08072e-15
c624_2361 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_70 c=3.26541e-15
c624_2360 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_69 c=3.07865e-15
c624_2359 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_68 c=3.27627e-15
c624_2358 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_67 c=3.07897e-15
c624_2357 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_66 c=3.25894e-15
c624_2356 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_65 c=3.28432e-15
c624_2355 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_64 c=4.90251e-15
c624_2354 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_63 c=3.2356e-15
c624_2353 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_62 c=3.23448e-15
c624_2352 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_61 c=3.24055e-15
c624_2351 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_60 c=3.24689e-15
c624_2350 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_59 c=3.19466e-15
c624_2349 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_58 c=3.25796e-15
c624_2348 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_57 c=3.0537e-15
c624_2347 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_56 c=3.23986e-15
c624_2346 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_55 c=3.06828e-15
c624_2345 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_54 c=3.24703e-15
c624_2344 xdut.gndd_p xdut.xosc.ln_pll_top_0.pll_core_0.lpf_0.n_53 c=3.26418e-15
c624_2343 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xlpf_0.net28 c=4.8359e-13
c624_2333 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_off_0.net113 c=4.65963e-15
c624_2332 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_off_0.net89 c=2.01859e-15
c624_2331 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_off_0.net57 c=2.6476e-15
c624_2330 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_off_0.net47 c=3.12341e-15
c624_2322 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xdiv36_0.xclk_div<32>0.clk c=1.75257e-15
c624_2308 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xpfd_std_0.xi53.c c=1.12439e-15
c624_2300 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xpfd_std_0.rn c=1.08697e-15
c624_2299 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xpfd_std_0.net135 c=1.15012e-15
c624_2243 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xlpf_0.pd_int c=1.11435e-15
c624_2242 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<60>.pullup c=3.96544e-15
c624_2241 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<61>.pullup c=3.96154e-15
c624_2240 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xdiv36_0.xclk_div<32>0.cmp c=1.14778e-15
c624_2233 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<62>.pullup c=3.96258e-15
c624_2232 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<63>.pullup c=3.95316e-15
c624_2226 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xpfd_std_0.xi111<0>.pullup c=1.86641e-15
c624_2184 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xdiv36_0.net13 c=1.26469e-15
c624_2110 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<65>.pullup c=3.95475e-15
c624_2109 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<64>.pullup c=3.96583e-15
c624_2108 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<58>.pullup c=3.99129e-15
c624_2107 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<66>.pullup c=3.95769e-15
c624_2106 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<67>.pullup c=3.95433e-15
c624_2105 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<68>.pullup c=3.96714e-15
c624_2097 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xpfd_std_0.xi54.c c=1.12572e-15
c624_2094 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.downz c=2.97392e-15
c624_2093 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.downqz c=2.76601e-15
c624_2085 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.upqz c=2.22276e-15
c624_2084 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xpfd_std_0.down_i c=1.13503e-15
c624_2077 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.down c=1.08296e-14
c624_2074 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.downq c=3.46573e-15
c624_2072 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xpfd_std_0.up_i c=1.22424e-15
c624_2070 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xpfd_std_0.up_n c=1.18488e-15
c624_2067 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.upz c=2.42723e-15
c624_2063 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.up c=5.28761e-15
c624_2061 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.pd_int c=1.67019e-14
c624_2059 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.pd_n c=2.87373e-14
c624_2055 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.hiz c=6.16253e-15
c624_2054 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.vhi c=1.21552e-15
c624_2053 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.vlo c=6.38412e-15
c624_2040 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.vtune c=9.25031e-14
c624_2039 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<57>.pullup c=3.99726e-15
c624_2038 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi11<1>.pullup c=1.84817e-15
c624_2034 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<59>.pullup c=3.96917e-15
c624_2031 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xpfd_std_0.xi111<1>.pullup c=1.86289e-15
c624_2026 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<69>.pullup c=3.98218e-15
c624_2022 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xdiv36_0.vh c=2.18915e-15
c624_2021 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.vctrl c=7.65015e-14
c624_2020 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xvi_0.net213 c=2.64308e-15
c624_2019 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xvi_0.net227 c=5.85443e-14
c624_2015 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xdiv36_0.vl c=2.18128e-15
c624_2010 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xdiv36_0.xdffrxl_0.c c=1.30336e-15
c624_1940 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.dp2_b c=2.87269e-15
c624_1938 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.dp1_b c=3.32789e-15
c624_1936 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.df<5> c=3.32085e-15
c624_1935 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.df<4> c=3.35062e-15
c624_1934 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.df<3> c=3.31313e-15
c624_1933 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.df<2> c=3.28459e-15
c624_1932 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.df<1> c=3.34299e-15
c624_1919 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<25>.pullup c=3.71398e-15
c624_1912 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.cb<5> c=4.62888e-15
c624_1908 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.dp2_gnd c=1.07101e-15
c624_1906 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.cout1 c=1.19512e-15
c624_1905 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.dp1_gnd c=1.09515e-15
c624_1904 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.xdf4.net154 c=1.40006e-15
c624_1903 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.xdf4.net155 c=1.40477e-15
c624_1902 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.xdf5.net154 c=1.43243e-15
c624_1901 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.xdf5.net155 c=1.43391e-15
c624_1900 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.xdf3.net155 c=1.43615e-15
c624_1899 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.net56 c=9.15432e-15
c624_1898 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.c<3> c=1.23834e-15
c624_1897 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.c<4> c=1.28275e-15
c624_1896 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.c<5> c=3.22544e-15
c624_1887 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.xdf1.net155 c=1.39313e-15
c624_1886 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.xdf2.net154 c=1.39971e-15
c624_1885 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.xdf2.net155 c=1.40457e-15
c624_1884 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.xdf3.net154 c=1.43326e-15
c624_1883 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.xdf1.net154 c=1.43461e-15
c624_1882 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.c<1> c=1.03616e-15
c624_1881 xdut.gndd_p xdut.xosc.xpll_top_0.xcco_0.xosc20m_0.c<2> c=1.29144e-15
c624_1874 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<30>.pullup c=3.70058e-15
c624_1873 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<11>.pullup c=3.96727e-15
c624_1868 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<35>.pullup c=3.69898e-15
c624_1859 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<38>.pullup c=3.70463e-15
c624_1857 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi12<2>.pullup c=1.01345e-15
c624_1855 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi12<1>.pullup c=1.00275e-15
c624_1854 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<9>.pullup c=3.96677e-15
c624_1853 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<10>.pullup c=3.96997e-15
c624_1852 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<7>.pullup c=3.96788e-15
c624_1851 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<8>.pullup c=3.96875e-15
c624_1850 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<12>.pullup c=3.97315e-15
c624_1849 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<41>.pullup c=3.71198e-15
c624_1842 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<0>.pullup c=3.93345e-15
c624_1840 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<44>.pullup c=3.70492e-15
c624_1839 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<13>.pullup c=3.72699e-15
c624_1838 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<2>.pullup c=3.92403e-15
c624_1836 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<14>.pullup c=3.73941e-15
c624_1835 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<15>.pullup c=3.92946e-15
c624_1834 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<16>.pullup c=3.93854e-15
c624_1828 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi11<0>.pullup c=2.04391e-15
c624_1827 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<18>.pullup c=3.89734e-15
c624_1826 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<19>.pullup c=3.9017e-15
c624_1825 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<47>.pullup c=3.70325e-15
c624_1819 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<21>.pullup c=3.95248e-15
c624_1818 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<22>.pullup c=4.07979e-15
c624_1817 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<23>.pullup c=3.85449e-15
c624_1816 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<24>.pullup c=3.88501e-15
c624_1809 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<26>.pullup c=3.93862e-15
c624_1808 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<27>.pullup c=4.06795e-15
c624_1807 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<50>.pullup c=3.7113e-15
c624_1806 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<29>.pullup c=3.8424e-15
c624_1805 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<28>.pullup c=3.85253e-15
c624_1801 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.vbiasp c=5.14756e-15
c624_1798 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<31>.pullup c=3.95419e-15
c624_1797 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<32>.pullup c=4.07925e-15
c624_1796 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<34>.pullup c=3.9009e-15
c624_1795 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<33>.pullup c=3.99081e-15
c624_1791 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.vcascp c=5.48453e-15
c624_1790 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<37>.pullup c=3.92146e-15
c624_1789 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<36>.pullup c=4.04265e-15
c624_1788 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<40>.pullup c=3.94807e-15
c624_1787 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<39>.pullup c=4.07753e-15
c624_1786 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<53>.pullup c=3.7155e-15
c624_1785 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<43>.pullup c=3.93471e-15
c624_1784 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<42>.pullup c=4.06993e-15
c624_1783 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<46>.pullup c=3.95472e-15
c624_1782 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<45>.pullup c=4.10429e-15
c624_1781 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<49>.pullup c=3.98254e-15
c624_1780 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<48>.pullup c=4.11166e-15
c624_1779 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<52>.pullup c=3.97451e-15
c624_1778 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<51>.pullup c=4.12009e-15
c624_1777 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<54>.pullup c=3.97202e-15
c624_1776 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<55>.pullup c=4.12193e-15
c624_1774 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<56>.pullup c=3.72795e-15
c624_1772 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<1>.pullup c=3.70069e-15
c624_1771 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.s1 c=1.33489e-15
c624_1770 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<3>.pullup c=3.70878e-15
c624_1762 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<17>.pullup c=3.71715e-15
c624_1761 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.s3 c=1.36725e-15
c624_1712 xdut.gndd_p xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.xi10<20>.pullup c=3.7001e-15
c624_1711 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xsc_top.int_high2 c=1.21201e-15
c624_1710 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xsc_top.int_high1 c=1.16065e-15
c624_1699 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xring.xdf5.net184 c=1.05463e-15
c624_1698 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xring.xdf5.net183 c=1.05624e-15
c624_1697 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xring.xdf4.net184 c=1.05381e-15
c624_1696 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xring.xdf4.net183 c=1.05056e-15
c624_1695 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xring.xdf3.net184 c=1.06165e-15
c624_1694 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xring.xdf3.net183 c=1.04949e-15
c624_1693 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xring.xdf2.net184 c=1.0518e-15
c624_1692 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xring.xdf2.net183 c=1.04572e-15
c624_1689 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xring.fouta c=1.7812e-15
c624_1688 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.dp2_b c=2.90721e-15
c624_1687 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.dp1_b c=3.31834e-15
c624_1686 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.df<5> c=3.34671e-15
c624_1685 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.df<4> c=3.57004e-15
c624_1684 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.df<3> c=3.4726e-15
c624_1683 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.df<2> c=3.33267e-15
c624_1682 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.df<1> c=3.27339e-15
c624_1659 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.sb<0> c=1.12759e-15
c624_1658 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.sb<2> c=1.39938e-15
c624_1657 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.sb<1> c=1.33247e-15
c624_1656 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.net78 c=1.0895e-15
c624_1650 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.net145 c=1.68104e-15
c624_1643 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.tcf_tr<1> c=1.22987e-15
c624_1642 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.tcf_tr<0> c=2.48412e-15
c624_1640 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xop_top.net80 c=2.71301e-15
c624_1628 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xcs_top.net100 c=2.3713e-15
c624_1627 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xcs_top.vbp c=8.70181e-15
c624_1596 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xdecoder.sb<6> c=1.32967e-14
c624_1575 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xdivider.xd1.cn c=1.3379e-15
c624_1548 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xdivider.xd1.c c=1.6646e-15
c624_1513 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.net400 c=1.19382e-14
c624_1499 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.fout10mb c=2.25801e-15
c624_1475 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xdivider.xd2.cn c=1.17684e-15
c624_1437 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xdivider.xd2.c c=1.67526e-15
c624_1407 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.net511 c=1.72649e-15
c624_1404 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xsc_top.xnor2.xi0_p1 c=6.13122e-15
c624_1377 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.vbn1 c=2.07411e-14
c624_1353 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.fout5mb c=1.3554e-15
c624_1340 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.net458 c=2.21406e-15
c624_1339 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.net173 c=6.75017e-15
c624_1338 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xsc_top.int c=4.54142e-14
c624_1320 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.net92 c=3.09985e-15
c624_1319 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.net94 c=2.92018e-15
c624_1318 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.net124 c=6.58096e-15
c624_1317 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.net84 c=1.84997e-15
c624_1316 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.net90 c=2.87622e-15
c624_1315 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.net86 c=2.24759e-15
c624_1314 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.net88 c=2.56653e-15
c624_1095 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.dout<0> c=1.4101e-15
c624_1079 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xdecoder.xd1.net65 c=1.74806e-15
c624_1047 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xop_top.vbn c=5.52933e-15
c624_1046 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xop_top.stg1 c=6.56226e-15
c624_1000 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.abus_enb c=1.35547e-15
c624_989 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xalr_top.xsch_ready.net34 c=1.1188e-15
c624_963 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.inp c=7.69801e-14
c624_939 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xsc_top.s c=4.15745e-15
c624_925 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xsc_top.sb c=4.27053e-15
c624_903 xdut.gndd_p xdut.xosc.xosc_20m_0.xatst_single_0.kx c=1.47008e-15
c624_902 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xcs_top.vstart c=3.06033e-15
c624_901 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xcs_top.net103 c=3.35191e-15
c624_900 xdut.gndd_p xdut.xosc.xosc_20m_0.xatst_single_0.atst_pll_5v c=1.20104e-15
c624_895 xdut.gndd_p xdut.xosc.xclkref_lpf_0.vdd_rc c=3.66739e-14
c624_894 xdut.gndd_p xdut.xosc.xosc_20m_0.xatst_single_0.xls_d2a_0.pull_up c=1.06481e-15
c624_893 xdut.gndd_p xdut.xosc.xclkref_lpf_0.net70 c=2.13684e-15
c624_887 xdut.gndd_p xdut.xosc.xosc_20m_0.xatst_single_0.atst_pll_int c=1.22072e-15
c624_884 xdut.gndd_p xdut.xana.xsup.xvddreg.xvddreg.net311 c=6.92427e-15
c624_882 xdut.gndd_p xdut.xana.xsup.xvddreg.xvddreg.vs_cl c=1.77868e-14
c624_881 xdut.gndd_p xdut.xana.xsup.xvccreg.xreg.nbl1 c=4.83235e-14
c624_878 xdut.gndd_p xdut.xana.xsup.xvccreg.xreg.net1108 c=2.04923e-14
c624_877 xdut.gndd_p xdut.xana.xsup.xvccreg.xreg.net1107 c=4.75543e-15
c624_876 xdut.gndd_p xdut.xana.xsup.xvccreg.xreg.gate c=7.17988e-15
c624_875 xdut.gndd_p xdut.xana.xsup.xvccreg.xreg.p0 c=2.03389e-14
c624_874 xdut.gndd_p xdut.xana.xsup.xvccreg.xreg.net878 c=6.17553e-15
c624_873 xdut.gndd_p xdut.xana.xsup.xvccreg.xreg.gain_i c=7.88924e-15
c624_872 xdut.gndd_p xdut.xana.xsup.xvccreg.xreg.startup_int c=2.69061e-15
c624_871 xdut.gndd_p xdut.xana.xsup.xvccreg.xreg.net770 c=1.93214e-15
c624_868 xdut.gndd_p xdut.xana.xsup.xvddreg.xvddreg.nbl1 c=3.99321e-14
c624_867 xdut.gndd_p xdut.xana.xsup.xvccreg.rdiv<25> c=8.69713e-15
c624_864 xdut.gndd_p xdut.xana.xsup.xref.xbg.net453 c=1.02867e-14
c624_863 xdut.gndd_p xdut.xana.xsup.xref.xbg.a c=3.15533e-14
c624_862 xdut.gndd_p xdut.xana.xsup.xref.xbg.net497 c=7.513e-15
c624_861 xdut.gndd_p xdut.xana.xsup.xref.xbg.net496 c=1.23917e-14
c624_859 xdut.gndd_p xdut.xana.xsup.xref.ibp1u<3> c=9.4528e-15
c624_858 xdut.gndd_p xdut.xana.xsup.xref.ibp1u<2> c=9.31281e-15
c624_857 xdut.gndd_p xdut.xana.xsup.xref.ibp1u<1> c=8.54342e-15
c624_856 xdut.gndd_p xdut.xana.xsup.xref.ibp1u<0> c=3.46806e-15
c624_855 xdut.gndd_p xdut.xana.xsup.xref.vref_iconst c=1.17752e-14
c624_831 xdut.gndd_p xdut.xana.xsup.atst_sup_5v<4> c=2.39016e-15
c624_825 xdut.gndd_p xdut.xana.xsup.i_trim_5v<0> c=2.53625e-15
c624_824 xdut.gndd_p xdut.xana.xsup.i_trim_5v<1> c=2.01092e-15
c624_817 xdut.gndd_p xdut.xana.xsup.xref.iaux10u c=2.51179e-14
c624_815 xdut.gndd_p xdut.xana.xsup.i_trim_5v<2> c=2.06467e-15
c624_814 xdut.gndd_p xdut.xana.xsup.ibp5u<1> c=1.16358e-15
c624_811 xdut.gndd_p xdut.xana.xsup.ic5u<12> c=9.26877e-15
c624_804 xdut.gndd_p xdut.xana.xsup.i_trim_5v<3> c=2.09741e-15
c624_801 xdut.gndd_p xdut.xana.xsup.xvbgbuf.vcc_nbl c=4.04686e-14
c624_798 xdut.gndd_p xdut.xana.xsup.ibp10u<1> c=1.98453e-15
c624_754 xdut.gndd_p xdut.xana.irp10u<3> c=2.18071e-15
c624_753 xdut.gndd_p xdut.xana.irp10u<2> c=1.91599e-15
c624_750 xdut.gndd_p xdut.xana.ic5u<3> c=1.15587e-15
c624_749 xdut.gndd_p xdut.xana.ic5u<6> c=1.33585e-15
c624_747 xdut.gndd_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.coms1 c=1.57706e-15
c624_746 xdut.gndd_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.vbn c=3.84156e-15
c624_745 xdut.gndd_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.vbp c=2.86587e-15
c624_742 xdut.gndd_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.n4 c=1.92656e-15
c624_741 xdut.gndd_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.net896 c=1.61219e-15
c624_740 xdut.gndd_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.net901 c=1.62123e-15
c624_739 xdut.gndd_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.net897 c=1.77382e-15
c624_738 xdut.gndd_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.net900 c=1.61219e-15
c624_737 xdut.gndd_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.net895 c=1.61219e-15
c624_736 xdut.gndd_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.n3 c=3.12852e-15
c624_735 xdut.gndd_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.net899 c=1.60689e-15
c624_734 xdut.gndd_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.net894 c=1.61844e-15
c624_732 xdut.gndd_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.n2 c=3.37699e-15
c624_731 xdut.gndd_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.n1 c=4.88506e-15
c624_730 xdut.gndd_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.net462 c=6.40958e-15
c624_729 xdut.gndd_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.preamp_r c=2.01783e-15
c624_713 xdut.gndd_p xdut.xana.xdsi_ch1<0>.xrx.idac_5v<1> c=1.22498e-15
c624_711 xdut.gndd_p xdut.xana.xdsi_ch1<0>.xrx.idac_5v<0> c=1.03136e-15
c624_710 xdut.gndd_p xdut.xana.xdsi_ch1<0>.xrx.idac_5v<2> c=2.69141e-15
c624_697 xdut.gndd_p xdut.xana.xdsi_ch1<0>.xrx.inp_iqcmp c=5.40855e-15
c624_695 xdut.gndd_p xdut.xana.xdsi_ch1<0>.xrx.inn_iqcmp c=6.37739e-15
c624_679 xdut.gndd_p xdut.xana.xdsi_ch1<0>.xrx.idac_5v<4> c=1.19275e-15
c624_677 xdut.gndd_p xdut.xana.xdsi_ch1<0>.xrx.idac2atb_5v c=2.14875e-15
c624_666 xdut.gndd_p xdut.xana.xsup.vrr_ok_5v c=3.25978e-15
c624_665 xdut.gndd_p xdut.xana.ic5u<11> c=7.98082e-15
c624_662 xdut.gndd_p xdut.xana.atst_otp<5> c=1.4543e-15
c624_661 xdut.gndd_p xdut.xana.atst_otp<4> c=1.42038e-15
c624_660 xdut.gndd_p xdut.xana.atst_otp<3> c=1.40945e-15
c624_659 xdut.gndd_p xdut.xana.atst_otp<2> c=1.40761e-15
c624_658 xdut.gndd_p xdut.xana.atst_otp<1> c=1.45488e-15
c624_657 xdut.gndd_p xdut.xana.atst_otp<0> c=1.4202e-15
c624_655 xdut.gndd_p xdut.xpad16.aoutb c=3.86318e-15
c624_653 xdut.gndd_p xdut.net2135 c=4.91405e-15
c624_651 xdut.gndd_p xdut.xpad17.gn c=1.42316e-15
c624_650 xdut.gndd_p xdut.xpad17.xlsgn.o1b c=1.44416e-15
c624_649 xdut.gndd_p xdut.xpad17.xlsgn.o1 c=1.79017e-15
c624_648 xdut.gndd_p xdut.xpad17.gnstrong c=1.23327e-15
c624_647 xdut.gndd_p xdut.xpad17.gnweak c=1.64486e-15
c624_645 xdut.gndd_p xdut.xpad17.gpweak c=1.61097e-15
c624_644 xdut.gndd_p xdut.xpad17.gp c=2.38055e-15
c624_642 xdut.gndd_p xdut.xpad17.xlsgp.o1b c=1.42844e-15
c624_641 xdut.gndd_p xdut.xpad17.xlsgp.o1 c=1.79714e-15
c624_640 xdut.gndd_p xdut.xpad17.ds_ls c=4.58394e-15
c624_639 xdut.gndd_p xdut.xpad17.dsb_ls c=2.94424e-15
c624_638 xdut.gndd_p xdut.xpad17.xlsds.o1b c=1.60036e-15
c624_637 xdut.gndd_p xdut.xpad17.xlsds.o1 c=2.10403e-15
c624_636 xdut.gndd_p xdut.xpad17.pd_ls c=5.70651e-15
c624_635 xdut.gndd_p xdut.xpad17.ie_ls c=2.79382e-15
c624_633 xdut.gndd_p xdut.xpad17.xlsie.o1b c=1.51585e-15
c624_632 xdut.gndd_p xdut.xpad17.xlsie.o1 c=2.15333e-15
c624_631 xdut.gndd_p xdut.xpad2.ds_ls c=4.6056e-15
c624_630 xdut.gndd_p xdut.xpad2.dsb_ls c=2.9756e-15
c624_629 xdut.gndd_p xdut.xpad2.xlsds.o1b c=1.60357e-15
c624_628 xdut.gndd_p xdut.xpad2.xlsds.o1 c=2.11065e-15
c624_627 xdut.gndd_p xdut.xpad2.gp c=2.37169e-15
c624_625 xdut.gndd_p xdut.xpad2.xlsgp.o1b c=1.43159e-15
c624_624 xdut.gndd_p xdut.xpad2.xlsgn.o1b c=1.45086e-15
c624_623 xdut.gndd_p xdut.xpad2.xlsgn.o1 c=1.7717e-15
c624_622 xdut.gndd_p xdut.xpad2.xlsgp.o1 c=1.77844e-15
c624_620 xdut.gndd_p xdut.xpad2.gn c=1.41335e-15
c624_619 xdut.gndd_p xdut.xpad2.gnstrong c=1.2298e-15
c624_618 xdut.gndd_p xdut.xpad2.gnweak c=1.65111e-15
c624_616 xdut.gndd_p xdut.xpad2.gpweak c=1.62034e-15
c624_615 xdut.gndd_p xdut.xpad17.aoutbb c=5.10797e-15
c624_612 xdut.gndd_p xdut.xpad17.xlspu.o1b c=1.39183e-15
c624_611 xdut.gndd_p xdut.xpad17.xlspu.o1 c=1.8336e-15
c624_609 xdut.gndd_p xdut.xpad17.xlspd.o1b c=1.46251e-15
c624_608 xdut.gndd_p xdut.xpad17.xlspd.o1 c=1.79993e-15
c624_606 xdut.gndd_p xdut.xpad17.aoutb c=3.86318e-15
c624_605 xdut.gndd_p xdut.net2134 c=4.92369e-15
c624_603 xdut.gndd_p xdut.xpad18.xlsgp.o1b c=1.42511e-15
c624_602 xdut.gndd_p xdut.xpad18.xlsgp.o1 c=1.79039e-15
c624_601 xdut.gndd_p xdut.xpad18.xlsds.o1b c=1.5945e-15
c624_600 xdut.gndd_p xdut.xpad18.xlsds.o1 c=2.09531e-15
c624_598 xdut.gndd_p xdut.xpad1.aoutb c=3.82251e-15
c624_597 xdut.gndd_p xdut.net2456 c=5.87241e-15
c624_594 xdut.gndd_p xdut.xpad1.xlspu.o1b c=1.43669e-15
c624_593 xdut.gndd_p xdut.xpad1.xlspu.o1 c=1.82963e-15
c624_591 xdut.gndd_p xdut.xpad1.xlspd.o1b c=1.43537e-15
c624_590 xdut.gndd_p xdut.xpad1.xlspd.o1 c=1.78657e-15
c624_588 xdut.gndd_p xdut.xpad1.pd_ls c=6.97182e-15
c624_587 xdut.gndd_p xdut.xpad18.ie_ls c=2.79239e-15
c624_585 xdut.gndd_p xdut.xpad18.xlsie.o1b c=1.51349e-15
c624_584 xdut.gndd_p xdut.xpad18.xlsie.o1 c=2.15067e-15
c624_583 xdut.gndd_p xdut.xpad18.xlspu.o1 c=1.83323e-15
c624_582 xdut.gndd_p xdut.xpad18.pd_ls c=5.70614e-15
c624_580 xdut.gndd_p xdut.xpad18.xlspd.o1b c=1.46219e-15
c624_579 xdut.gndd_p xdut.xpad18.xlspd.o1 c=1.79258e-15
c624_578 xdut.gndd_p xdut.xpad18.aoutbb c=5.10744e-15
c624_575 xdut.gndd_p xdut.xpad18.xlspu.o1b c=1.39287e-15
c624_573 xdut.gndd_p xdut.xpad18.aoutb c=3.86277e-15
c624_572 xdut.gndd_p xdut.net2138 c=4.94894e-15
c624_571 xdut.gndd_p xdut.xpad1.gp c=2.37435e-15
c624_569 xdut.gndd_p xdut.xpad1.xlsgp.o1b c=1.4312e-15
c624_568 xdut.gndd_p xdut.xpad1.ds_ls c=4.5977e-15
c624_567 xdut.gndd_p xdut.xpad1.dsb_ls c=2.96263e-15
c624_566 xdut.gndd_p xdut.xpad1.xlsds.o1b c=1.60288e-15
c624_565 xdut.gndd_p xdut.xpad1.xlsds.o1 c=2.1104e-15
c624_563 xdut.gndd_p xdut.xpad1.gn c=1.41337e-15
c624_562 xdut.gndd_p xdut.xpad1.xlsgn.o1b c=1.45067e-15
c624_561 xdut.gndd_p xdut.xpad1.xlsgn.o1 c=1.77154e-15
c624_560 xdut.gndd_p xdut.xpad1.xlsgp.o1 c=1.78268e-15
c624_559 xdut.gndd_p xdut.xpad1.gnstrong c=1.23066e-15
c624_558 xdut.gndd_p xdut.xpad1.gnweak c=1.65135e-15
c624_556 xdut.gndd_p xdut.xpad1.gpweak c=1.62907e-15
c624_555 xdut.gndd_p xdut.net2140 c=4.96778e-15
c624_553 xdut.gndd_p xdut.xpad2.aoutb c=3.87762e-15
c624_552 xdut.gndd_p xdut.xpad2.aoutbb c=5.16884e-15
c624_549 xdut.gndd_p xdut.xpad2.xlspu.o1b c=1.40175e-15
c624_548 xdut.gndd_p xdut.xpad2.xlspu.o1 c=1.82342e-15
c624_547 xdut.gndd_p xdut.xpad2.pd_ls c=5.71729e-15
c624_545 xdut.gndd_p xdut.xpad2.xlspd.o1b c=1.45946e-15
c624_544 xdut.gndd_p xdut.xpad2.xlspd.o1 c=1.80727e-15
c624_542 xdut.gndd_p xdut.xpad2.ie_ls c=2.79006e-15
c624_540 xdut.gndd_p xdut.xpad2.xlsie.o1b c=1.51274e-15
c624_539 xdut.gndd_p xdut.xpad2.xlsie.o1 c=2.15554e-15
c624_538 xdut.gndd_p xdut.xpad21.aoutbb c=5.19996e-15
c624_536 xdut.gndd_p xdut.xpad21.aoutb c=3.86076e-15
c624_535 xdut.gndd_p xdut.net2130 c=4.96719e-15
c624_532 xdut.gndd_p xdut.xpad21.xlspu.o1b c=1.41305e-15
c624_531 xdut.gndd_p xdut.xpad21.xlspu.o1 c=1.81871e-15
c624_530 xdut.gndd_p xdut.xpad21.xlspd.o1b c=1.46192e-15
c624_529 xdut.gndd_p xdut.xpad21.xlspd.o1 c=1.80559e-15
c624_527 xdut.gndd_p xdut.xpad21.pd_ls c=5.71809e-15
c624_525 xdut.gndd_p xdut.xpad21.ie_ls c=2.79714e-15
c624_523 xdut.gndd_p xdut.xpad21.xlsie.o1b c=1.51127e-15
c624_522 xdut.gndd_p xdut.xpad21.xlsie.o1 c=2.13351e-15
c624_521 xdut.gndd_p xdut.xpad21.ds_ls c=4.59568e-15
c624_520 xdut.gndd_p xdut.xpad21.dsb_ls c=2.96086e-15
c624_519 xdut.gndd_p xdut.xpad21.xlsds.o1b c=1.60137e-15
c624_518 xdut.gndd_p xdut.xpad21.xlsds.o1 c=2.11274e-15
c624_517 xdut.gndd_p xdut.xpad21.gp c=2.37019e-15
c624_515 xdut.gndd_p xdut.xpad21.xlsgp.o1b c=1.42978e-15
c624_514 xdut.gndd_p xdut.xpad21.xlsgp.o1 c=1.78247e-15
c624_513 xdut.gndd_p xdut.xpad21.gn c=1.40575e-15
c624_512 xdut.gndd_p xdut.xpad21.xlsgn.o1b c=1.45224e-15
c624_511 xdut.gndd_p xdut.xpad21.xlsgn.o1 c=1.80775e-15
c624_509 xdut.gndd_p xdut.xpad21.gnstrong c=1.21217e-15
c624_508 xdut.gndd_p xdut.xpad21.gnweak c=1.65324e-15
c624_507 xdut.gndd_p xdut.xpad21.gpweak c=1.61929e-15
c624_505 xdut.gndd_p xdut.xpad22.aoutbb c=5.19629e-15
c624_503 xdut.gndd_p xdut.xpad22.aoutb c=3.86079e-15
c624_502 xdut.gndd_p xdut.net2131 c=4.96801e-15
c624_499 xdut.gndd_p xdut.xpad22.xlspu.o1b c=1.41314e-15
c624_498 xdut.gndd_p xdut.xpad22.xlspu.o1 c=1.81874e-15
c624_496 xdut.gndd_p xdut.xpad22.xlspd.o1b c=1.46192e-15
c624_495 xdut.gndd_p xdut.xpad22.xlspd.o1 c=1.80559e-15
c624_493 xdut.gndd_p xdut.xpad22.pd_ls c=5.70863e-15
c624_492 xdut.gndd_p xdut.xpad22.ie_ls c=2.79649e-15
c624_490 xdut.gndd_p xdut.xpad22.xlsie.o1b c=1.51127e-15
c624_489 xdut.gndd_p xdut.xpad22.xlsie.o1 c=2.13351e-15
c624_488 xdut.gndd_p xdut.xpad22.gp c=2.3699e-15
c624_487 xdut.gndd_p xdut.xpad22.ds_ls c=4.59568e-15
c624_486 xdut.gndd_p xdut.xpad22.dsb_ls c=2.96095e-15
c624_485 xdut.gndd_p xdut.xpad22.xlsds.o1b c=1.60137e-15
c624_484 xdut.gndd_p xdut.xpad22.xlsds.o1 c=2.11274e-15
c624_482 xdut.gndd_p xdut.xpad22.gn c=1.40338e-15
c624_481 xdut.gndd_p xdut.xpad22.xlsgn.o1b c=1.45224e-15
c624_480 xdut.gndd_p xdut.xpad22.xlsgn.o1 c=1.80775e-15
c624_478 xdut.gndd_p xdut.xpad22.xlsgp.o1b c=1.42978e-15
c624_477 xdut.gndd_p xdut.xpad22.xlsgp.o1 c=1.78247e-15
c624_476 xdut.gndd_p xdut.xpad22.gnstrong c=1.21184e-15
c624_475 xdut.gndd_p xdut.xpad22.gnweak c=1.65443e-15
c624_474 xdut.gndd_p xdut.xpad22.gpweak c=1.61933e-15
c624_472 xdut.gndd_p xdut.xpad23.aoutbb c=5.19763e-15
c624_470 xdut.gndd_p xdut.xpad23.aoutb c=3.86399e-15
c624_469 xdut.gndd_p xdut.net2132 c=4.94875e-15
c624_466 xdut.gndd_p xdut.xpad23.xlspu.o1b c=1.41314e-15
c624_465 xdut.gndd_p xdut.xpad23.xlspu.o1 c=1.81874e-15
c624_462 xdut.gndd_p xdut.xpad23.xlspd.o1b c=1.46192e-15
c624_461 xdut.gndd_p xdut.xpad23.xlspd.o1 c=1.80559e-15
c624_460 xdut.gndd_p xdut.trim_dsi_rx2<4> c=1.95743e-15
c624_459 xdut.gndd_p xdut.xpad23.pd_ls c=5.70936e-15
c624_458 xdut.gndd_p xdut.trim_dsi_rx2<5> c=2.01829e-15
c624_457 xdut.gndd_p xdut.trim_dsi_rx2<6> c=1.90765e-15
c624_456 xdut.gndd_p xdut.trim_dsi_rx1<5> c=1.93437e-15
c624_455 xdut.gndd_p xdut.trim_dsi_rx1<4> c=1.91904e-15
c624_454 xdut.gndd_p xdut.trim_dsi_rx2<7> c=1.90577e-15
c624_453 xdut.gndd_p xdut.trim_dsi_rx1<6> c=1.95152e-15
c624_452 xdut.gndd_p xdut.dsi_rx_on<1> c=1.64633e-15
c624_451 xdut.gndd_p xdut.trim_dsi_rx1<7> c=1.8396e-15
c624_450 xdut.gndd_p xdut.atst_tx<11> c=4.47935e-15
c624_449 xdut.gndd_p xdut.atst_tx<10> c=4.65676e-15
c624_448 xdut.gndd_p xdut.atst_tx<9> c=8.62346e-15
c624_447 xdut.gndd_p xdut.atst_tx<8> c=7.61967e-15
c624_446 xdut.gndd_p xdut.atst_tx<7> c=1.11139e-14
c624_445 xdut.gndd_p xdut.dsi_tx_on<1> c=8.7249e-15
c624_444 xdut.gndd_p xdut.dsi_tx_hvcasc<1> c=4.20747e-15
c624_443 xdut.gndd_p xdut.dsi_ok<1> c=3.73855e-15
c624_442 xdut.gndd_p xdut.atst_tx<12> c=3.73127e-15
c624_441 xdut.gndd_p xdut.dsi_tx_on<0> c=1.07595e-14
c624_440 xdut.gndd_p xdut.dsi_tx_hvcasc<0> c=4.8329e-15
c624_439 xdut.gndd_p xdut.dsi_ok<0> c=4.11323e-15
c624_438 xdut.gndd_p xdut.xpad23.ie_ls c=2.79714e-15
c624_437 xdut.gndd_p xdut.atst_tx<5> c=4.00872e-15
c624_436 xdut.gndd_p xdut.atst_tx<4> c=4.0472e-15
c624_435 xdut.gndd_p xdut.atst_tx<3> c=4.03998e-15
c624_434 xdut.gndd_p xdut.atst_tx<2> c=4.82975e-15
c624_433 xdut.gndd_p xdut.atst_tx<1> c=6.71479e-15
c624_432 xdut.gndd_p xdut.atst_tx<0> c=8.96577e-15
c624_431 xdut.gndd_p xdut.dsi_tx_data<4> c=3.74263e-15
c624_430 xdut.gndd_p xdut.dsi_tx_data<3> c=3.50552e-15
c624_429 xdut.gndd_p xdut.dsi_tx_data<1> c=4.61936e-15
c624_428 xdut.gndd_p xdut.atst_tx<6> c=7.83604e-15
c624_427 xdut.gndd_p xdut.dsi_tx_tbit_cfg<1> c=6.95159e-15
c624_426 xdut.gndd_p xdut.dsi_tx_tbit_cfg<0> c=8.16742e-15
c624_425 xdut.gndd_p xdut.dsi_rx_txn<0> c=1.08993e-14
c624_424 xdut.gndd_p xdut.dsi_ov<0> c=1.2866e-14
c624_423 xdut.gndd_p xdut.dsi_rx_on<0> c=1.94147e-14
c624_422 xdut.gndd_p xdut.atst_rx<0> c=1.89984e-14
c624_421 xdut.gndd_p xdut.trim_dsi_rx1<3> c=1.59959e-14
c624_420 xdut.gndd_p xdut.trim_dsi_rx1<2> c=1.60054e-14
c624_418 xdut.gndd_p xdut.trim_dsi_rx1<1> c=1.59669e-14
c624_417 xdut.gndd_p xdut.trim_dsi_rx1<0> c=1.59941e-14
c624_416 xdut.gndd_p xdut.trim_dsi_rx2<3> c=1.58294e-14
c624_415 xdut.gndd_p xdut.trim_dsi_rx2<2> c=1.63442e-14
c624_414 xdut.gndd_p xdut.trim_dsi_rx2<1> c=1.63916e-14
c624_413 xdut.gndd_p xdut.trim_dsi_rx2<0> c=1.62587e-14
c624_412 xdut.gndd_p xdut.dsi_rx_filter_fast<0> c=4.74505e-14
c624_411 xdut.gndd_p xdut.dsi_rxd1<0> c=1.7034e-14
c624_410 xdut.gndd_p xdut.dsi_rxd2<0> c=2.25438e-14
c624_409 xdut.gndd_p xdut.intb_o c=1.67877e-15
c624_408 xdut.gndd_p xdut.intb_oe c=1.76969e-15
c624_407 xdut.gndd_p xdut.intb_pu c=2.00654e-15
c624_406 xdut.gndd_p xdut.intb_pd c=1.60739e-15
c624_405 xdut.gndd_p xdut.intb_ie c=1.68726e-15
c624_404 xdut.gndd_p xdut.intb_i c=1.49761e-15
c624_403 xdut.gndd_p xdut.xpad23.xlsie.o1b c=1.51127e-15
c624_402 xdut.gndd_p xdut.dab_i c=1.38366e-15
c624_401 xdut.gndd_p xdut.dab_oe c=1.72005e-15
c624_400 xdut.gndd_p xdut.dab_pd c=1.49141e-15
c624_399 xdut.gndd_p xdut.dab_ie c=1.60732e-15
c624_398 xdut.gndd_p xdut.dab_o c=1.58249e-15
c624_397 xdut.gndd_p xdut.dab_pu c=1.88687e-15
c624_396 xdut.gndd_p xdut.resb_i c=1.69426e-15
c624_395 xdut.gndd_p xdut.xpad23.xlsie.o1 c=2.13351e-15
c624_394 xdut.gndd_p xdut.net3137 c=5.68522e-15
c624_393 xdut.gndd_p xdut.syncb_oe c=1.70844e-15
c624_392 xdut.gndd_p xdut.syncb_i c=1.36766e-15
c624_391 xdut.gndd_p xdut.syncb_o c=1.48788e-15
c624_390 xdut.gndd_p xdut.syncb_ie c=1.60024e-15
c624_389 xdut.gndd_p xdut.syncb_pd c=1.6208e-15
c624_388 xdut.gndd_p xdut.syncb_pu c=1.85557e-15
c624_387 xdut.gndd_p xdut.xpad23.gp c=2.3699e-15
c624_386 xdut.gndd_p xdut.bfwb_o c=1.90219e-15
c624_385 xdut.gndd_p xdut.bfwb_oe c=1.71213e-15
c624_384 xdut.gndd_p xdut.bfwb_i c=1.82019e-15
c624_383 xdut.gndd_p xdut.bfwb_ie c=2.06432e-15
c624_382 xdut.gndd_p xdut.bfwb_pd c=1.72902e-15
c624_381 xdut.gndd_p xdut.xpad23.ds_ls c=4.59568e-15
c624_380 xdut.gndd_p xdut.xpad23.dsb_ls c=2.96298e-15
c624_379 xdut.gndd_p xdut.xpad23.xlsds.o1b c=1.60137e-15
c624_378 xdut.gndd_p xdut.bfwb_pu c=1.8658e-15
c624_377 xdut.gndd_p xdut.xpad23.xlsds.o1 c=2.11274e-15
c624_375 xdut.gndd_p xdut.rfc_oe c=1.88653e-15
c624_374 xdut.gndd_p xdut.rfc_o c=1.57064e-15
c624_373 xdut.gndd_p xdut.rfc_pu c=1.89206e-15
c624_372 xdut.gndd_p xdut.rfc_pd c=1.52714e-15
c624_371 xdut.gndd_p xdut.rfc_ie c=1.63273e-15
c624_370 xdut.gndd_p xdut.rfc_i c=1.35865e-15
c624_369 xdut.gndd_p xdut.xpad23.gn c=1.4081e-15
c624_368 xdut.gndd_p xdut.net3316 c=1.05279e-14
c624_367 xdut.gndd_p xdut.net3135 c=4.8951e-15
c624_366 xdut.gndd_p xdut.xpad23.xlsgn.o1b c=1.45224e-15
c624_365 xdut.gndd_p xdut.xpad23.xlsgn.o1 c=1.80775e-15
c624_363 xdut.gndd_p xdut.sdo_o c=3.58823e-15
c624_362 xdut.gndd_p xdut.sdo_i c=3.46556e-15
c624_361 xdut.gndd_p xdut.sdo_ie c=3.71867e-15
c624_360 xdut.gndd_p xdut.sdo_pd c=3.33244e-15
c624_359 xdut.gndd_p xdut.sdo_pu c=4.60028e-15
c624_358 xdut.gndd_p xdut.sdo_oe c=4.07062e-15
c624_357 xdut.gndd_p xdut.xpad23.xlsgp.o1b c=1.42978e-15
c624_356 xdut.gndd_p xdut.xpad23.xlsgp.o1 c=1.78247e-15
c624_355 xdut.gndd_p xdut.sdi_pu c=2.64223e-15
c624_354 xdut.gndd_p xdut.sdi_i c=2.01841e-15
c624_353 xdut.gndd_p xdut.sdi_ie c=2.22939e-15
c624_352 xdut.gndd_p xdut.sdi_pd c=2.14003e-15
c624_351 xdut.gndd_p xdut.sdi_o c=2.24627e-15
c624_350 xdut.gndd_p xdut.sdi_oe c=2.55319e-15
c624_349 xdut.gndd_p xdut.sck_pu c=3.27534e-15
c624_348 xdut.gndd_p xdut.sck_pd c=2.80622e-15
c624_347 xdut.gndd_p xdut.sck_o c=2.60829e-15
c624_346 xdut.gndd_p xdut.sck_i c=2.43538e-15
c624_345 xdut.gndd_p xdut.sck_ie c=2.70587e-15
c624_344 xdut.gndd_p xdut.sck_oe c=3.00596e-15
c624_343 xdut.gndd_p xdut.csb_pu c=3.97188e-15
c624_342 xdut.gndd_p xdut.csb_pd c=3.01714e-15
c624_341 xdut.gndd_p xdut.csb_ie c=3.17458e-15
c624_340 xdut.gndd_p xdut.csb_i c=3.02302e-15
c624_339 xdut.gndd_p xdut.csb_oe c=4.65362e-15
c624_338 xdut.gndd_p xdut.csb_o c=2.83276e-15
c624_337 xdut.gndd_p xdut.xpad23.gnstrong c=1.21184e-15
c624_336 xdut.gndd_p xdut.xpad23.gnweak c=1.65322e-15
c624_335 xdut.gndd_p xdut.atst_rx<1> c=2.43698e-15
c624_334 xdut.gndd_p xdut.dsi_rxd2<1> c=2.26546e-15
c624_333 xdut.gndd_p xdut.dsi_rx_filter_fast<1> c=2.10894e-15
c624_332 xdut.gndd_p xdut.dsi_rxd1<1> c=2.23753e-15
c624_331 xdut.gndd_p xdut.dsi_tx_tbit_cfg<3> c=1.92203e-15
c624_330 xdut.gndd_p xdut.atst_tx<13> c=2.03446e-15
c624_329 xdut.gndd_p xdut.dsi_ov<1> c=2.4454e-15
c624_328 xdut.gndd_p xdut.dsi_rx_txn<1> c=2.13628e-15
c624_327 xdut.gndd_p xdut.dsi_tx_data<9> c=2.07537e-15
c624_326 xdut.gndd_p xdut.dsi_tx_tbit_cfg<2> c=1.91129e-15
c624_325 xdut.gndd_p xdut.dsi_idac<7> c=1.60777e-15
c624_324 xdut.gndd_p xdut.dsi_idac<8> c=2.06731e-15
c624_323 xdut.gndd_p xdut.dsi_idac<5> c=1.75549e-15
c624_322 xdut.gndd_p xdut.dsi_idac<9> c=1.89946e-15
c624_321 xdut.gndd_p xdut.dsi_idac<6> c=1.22033e-15
c624_320 xdut.gndd_p xdut.dsi_icmp<1> c=2.17342e-15
c624_319 xdut.gndd_p xdut.dsi_icmp<0> c=6.77529e-15
c624_318 xdut.gndd_p xdut.dsi_idac<3> c=1.58272e-14
c624_317 xdut.gndd_p xdut.dsi_idac<0> c=1.08763e-14
c624_316 xdut.gndd_p xdut.dsi_idac<1> c=9.97777e-15
c624_315 xdut.gndd_p xdut.dsi_idac<2> c=1.54699e-14
c624_314 xdut.gndd_p xdut.xpad23.gpweak c=1.61895e-15
c624_312 xdut.gndd_p xdut.trim_osc_f<4> c=8.61279e-15
c624_311 xdut.gndd_p xdut.trim_osc_f<2> c=6.67817e-15
c624_310 xdut.gndd_p xdut.trim_osc_f<5> c=7.84612e-15
c624_309 xdut.gndd_p xdut.trim_osc_f<3> c=8.49507e-15
c624_308 xdut.gndd_p xdut.trim_osc_f<0> c=2.76809e-14
c624_307 xdut.gndd_p xdut.trim_osc_f<6> c=9.75081e-15
c624_306 xdut.gndd_p xdut.trim_osc_f<1> c=8.96718e-15
c624_305 xdut.gndd_p xdut.vdd_nbl c=2.39942e-12
c624_304 xdut.gndd_p xdut.xpad24.aoutbb c=5.19482e-15
c624_302 xdut.gndd_p xdut.por_1v8 c=1.78842e-14
c624_300 xdut.gndd_p xdut.otp_vrr c=6.58565e-14
c624_299 xdut.gndd_p xdut.xpad24.aoutb c=3.85255e-15
c624_298 xdut.gndd_p xdut.otp_vref c=1.52774e-14
c624_297 xdut.gndd_p xdut.net3230 c=4.97718e-15
c624_296 xdut.gndd_p xdut.dsi_idac<4> c=1.96969e-14
c624_294 xdut.gndd_p xdut.xpad24.xlspu.o1b c=1.40979e-15
c624_293 xdut.gndd_p xdut.pll_ic5u c=6.00207e-14
c624_292 xdut.gndd_p xdut.xpad24.xlspu.o1 c=1.81048e-15
c624_291 xdut.gndd_p xdut.xpad24.pd_ls c=5.70742e-15
c624_289 xdut.gndd_p xdut.otp_ehv_1v8 c=3.73755e-15
c624_288 xdut.gndd_p xdut.otp_vpp c=1.12986e-14
c624_286 xdut.gndd_p xdut.ldo_en c=9.44211e-15
c624_285 xdut.gndd_p xdut.dsi_tx_data<7> c=1.8051e-15
c624_284 xdut.gndd_p xdut.dsi_tx_data<8> c=1.73215e-15
c624_283 xdut.gndd_p xdut.dsi_tx_data<5> c=1.87905e-15
c624_282 xdut.gndd_p xdut.dsi_tx_data<6> c=1.86634e-15
c624_281 xdut.gndd_p xdut.ldo_ok c=8.24978e-15
c624_280 xdut.gndd_p xdut.xpad24.xlspd.o1b c=1.46092e-15
c624_279 xdut.gndd_p xdut.dsi_tx_data<2> c=4.06089e-15
c624_278 xdut.gndd_p xdut.dsi_tx_data<0> c=8.84409e-15
c624_277 xdut.gndd_p xdut.atst_osc<1> c=1.4278e-14
c624_276 xdut.gndd_p xdut.atst_osc<0> c=1.59823e-14
c624_275 xdut.gndd_p xdut.atst_osc<2> c=1.88297e-14
c624_274 xdut.gndd_p xdut.trim_osc_tcf<2> c=2.44724e-14
c624_273 xdut.gndd_p xdut.trim_osc_tcf<1> c=1.22268e-14
c624_272 xdut.gndd_p xdut.trim_osc_tcf<0> c=1.65105e-14
c624_271 xdut.gndd_p xdut.xpad24.xlspd.o1 c=1.80179e-15
c624_270 xdut.gndd_p xdut.osc_ready c=1.05088e-14
c624_269 xdut.gndd_p xdut.clkosc c=1.93414e-14
c624_268 xdut.gndd_p xdut.clkref_filt c=8.17998e-15
c624_266 xdut.gndd_p xdut.osc_on c=2.1186e-14
c624_265 xdut.gndd_p xdut.atst_pll<6> c=9.20729e-15
c624_264 xdut.gndd_p xdut.atst_pll<5> c=6.02139e-15
c624_263 xdut.gndd_p xdut.atst_pll<4> c=6.40923e-15
c624_262 xdut.gndd_p xdut.atst_pll<3> c=6.53599e-15
c624_261 xdut.gndd_p xdut.atst_pll<2> c=6.60853e-15
c624_260 xdut.gndd_p xdut.pll_hold c=4.87462e-15
c624_259 xdut.gndd_p xdut.xpad24.ie_ls c=2.79466e-15
c624_258 xdut.gndd_p xdut.pll_down_mon c=6.26278e-15
c624_257 xdut.gndd_p xdut.pll_lock_mon c=6.5843e-15
c624_256 xdut.gndd_p xdut.atst_pll<0> c=6.7794e-15
c624_255 xdut.gndd_p xdut.atst_pll<1> c=6.82762e-15
c624_254 xdut.gndd_p xdut.clkpll c=1.51168e-14
c624_253 xdut.gndd_p xdut.clkpll_div c=1.12993e-14
c624_252 xdut.gndd_p xdut.pll_up_mon c=4.48612e-15
c624_251 xdut.gndd_p xdut.pll_on c=2.26833e-14
c624_250 xdut.gndd_p xdut.atst_sup<0> c=6.24568e-15
c624_249 xdut.gndd_p xdut.vdd_rdiv_dis c=1.03903e-14
c624_248 xdut.gndd_p xdut.vdd_iload_dis c=1.54663e-14
c624_247 xdut.gndd_p xdut.clkref_pll c=1.16485e-14
c624_246 xdut.gndd_p xdut.clkref_i c=3.66437e-14
c624_245 xdut.gndd_p xdut.clkref_ie c=2.40612e-14
c624_244 xdut.gndd_p xdut.pad_ds c=1.25835e-13
c624_243 xdut.gndd_p xdut.tmode_i c=1.48143e-14
c624_242 xdut.gndd_p xdut.por_n c=6.09367e-15
c624_241 xdut.gndd_p xdut.vrr_ok c=5.85934e-15
c624_240 xdut.gndd_p xdut.atst_sup<4> c=5.52636e-15
c624_239 xdut.gndd_p xdut.trim_i5u<0> c=5.56627e-15
c624_237 xdut.gndd_p xdut.trim_i5u<1> c=5.39454e-15
c624_236 xdut.gndd_p xdut.trim_i5u<2> c=4.83873e-15
c624_235 xdut.gndd_p xdut.trim_i5u<3> c=4.32981e-15
c624_234 xdut.gndd_p xdut.vcc_ok c=4.22496e-15
c624_233 xdut.gndd_p xdut.atst_sup<3> c=5.51993e-15
c624_232 xdut.gndd_p xdut.atst_sup<2> c=5.95324e-15
c624_231 xdut.gndd_p xdut.atst_sup<1> c=6.09995e-15
c624_230 xdut.gndd_p xdut.reg_vdd_dis c=3.35164e-14
c624_229 xdut.gndd_p xdut.xpad24.xlsie.o1b c=1.5101e-15
c624_228 xdut.gndd_p xdut.xpad24.xlsie.o1 c=2.14096e-15
c624_227 xdut.gndd_p xdut.xpad24.gp c=2.36973e-15
c624_225 xdut.gndd_p xdut.xpad24.ds_ls c=4.59075e-15
c624_224 xdut.gndd_p xdut.aout_int c=1.78229e-13
c624_223 xdut.gndd_p xdut.xpad24.dsb_ls c=2.96373e-15
c624_222 xdut.gndd_p xdut.xpad24.xlsds.o1b c=1.60153e-15
c624_221 xdut.gndd_p xdut.xpad24.xlsds.o1 c=2.09975e-15
c624_220 xdut.gndd_p xdut.xpad24.xlsgp.o1b c=1.4282e-15
c624_219 xdut.gndd_p xdut.xpad24.xlsgp.o1 c=1.76899e-15
c624_217 xdut.gndd_p xdut.xpad24.gn c=1.40786e-15
c624_216 xdut.gndd_p xdut.xpad24.xlsgn.o1b c=1.45017e-15
c624_215 xdut.gndd_p xdut.xpad24.xlsgn.o1 c=1.78739e-15
c624_214 xdut.gndd_p xdut.xpad24.gnstrong c=1.20684e-15
c624_213 xdut.gndd_p xdut.xpad24.gnweak c=1.64308e-15
c624_211 xdut.gndd_p xdut.xpad24.gpweak c=1.61021e-15
c624_209 xdut.gndd_p xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd c=5.37889e-15
c624_208 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xcs_top.bh c=6.57252e-14
c624_207 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xcs_top.bl c=3.14765e-14
c624_206 xdut.gndd_p xdut.xana.xsup.xvddreg.xvddreg.v5raw c=1.10106e-13
c624_205 xdut.gndd_p xdut.xana.xsup.xvddreg.xvddreg.net339 c=1.12752e-14
c624_204 xdut.gndd_p xdut.xana.xsup.xvccreg.xreg.n2_net c=2.04913e-15
c624_203 xdut.gndd_p xdut.xana.xsup.xvccreg.xreg.n1_net c=1.17761e-15
c624_202 xdut.gndd_p xdut.xana.xsup.xvccreg.xreg.net830 c=4.2395e-15
c624_201 xdut.gndd_p xdut.xana.xsup.xvccreg.xreg.net851 c=1.10244e-14
c624_200 xdut.gndd_p xdut.xana.xsup.xvccreg.xreg.net818 c=7.27374e-15
c624_199 xdut.gndd_p xdut.xana.xsup.xvccreg.xreg.vbat c=7.84181e-14
c624_198 xdut.gndd_p xdut.xpad5_vcc.net_1 c=5.4936e-14
c624_197 xdut.gndd_p xdut.xpad5_vcc.net_2 c=5.69597e-14
c624_196 xdut.gndd_p xdut.xi75.net_1 c=5.6501e-14
c624_195 xdut.gndd_p xdut.xpad20_gndio.net_0 c=5.65781e-14
c624_194 xdut.gndd_p xdut.xi74.net_1 c=5.65816e-14
c624_193 xdut.gndd_p xdut.xpad19_vio.net_1 c=6.88518e-14
c624_191 xdut.gndd_p xdut.en_atb c=1.0066e-14
c624_190 xdut.gndd_p xdut.atst_ts<1> c=2.31457e-14
c624_189 xdut.gndd_p xdut.ot_warn c=5.76878e-14
c624_188 xdut.gndd_p xdut.ot_error c=2.66519e-14
c624_187 xdut.gndd_p xdut.ot_adj<0> c=2.33232e-14
c624_186 xdut.gndd_p xdut.atst_ts<0> c=5.2369e-14
c624_185 xdut.gndd_p xdut.ot_adj<1> c=2.20454e-14
c624_184 xdut.gndd_p xdut.net3455 c=2.6315e-15
c624_183 xdut.gndd_p xdut.xpad13.dst1 c=1.36981e-15
c624_181 xdut.gndd_p xdut.xpad13.net424 c=3.00814e-15
c624_180 xdut.gndd_p xdut.xpad14.net424 c=3.00554e-15
c624_179 xdut.gndd_p xdut.xpad14.dst1 c=1.36942e-15
c624_177 xdut.gndd_p xdut.xpad15.net424 c=3.00877e-15
c624_176 xdut.gndd_p xdut.xpad15.dst1 c=1.3693e-15
c624_174 xdut.gndd_p xdut.xpad16.net424 c=3.00336e-15
c624_173 xdut.gndd_p xdut.xpad16.dst1 c=1.3693e-15
c624_171 xdut.gndd_p xdut.xpad17.net424 c=3.00846e-15
c624_170 xdut.gndd_p xdut.xpad17.dst1 c=1.3693e-15
c624_168 xdut.gndd_p xdut.xpad18.net424 c=3.00689e-15
c624_166 xdut.gndd_p xdut.xpad18.dst1 c=1.3693e-15
c624_165 xdut.gndd_p xdut.xpad1.net424 c=3.37297e-15
c624_163 xdut.gndd_p xdut.xpad1.dst1 c=1.15034e-15
c624_162 xdut.gndd_p xdut.xpad2.net424 c=3.01029e-15
c624_160 xdut.gndd_p xdut.xpad2.dst1 c=1.37438e-15
c624_159 xdut.gndd_p xdut.xpad21.net424 c=3.00542e-15
c624_158 xdut.gndd_p xdut.xpad21.dst1 c=1.37148e-15
c624_156 xdut.gndd_p xdut.gnd_dsi c=1.19351e-12
c624_155 xdut.gndd_p xdut.xpad22.net424 c=3.01386e-15
c624_153 xdut.gndd_p xdut.xpad22.dst1 c=1.37146e-15
c624_152 xdut.gndd_p xdut.xpad23.net424 c=3.00662e-15
c624_151 xdut.gndd_p xdut.xpad23.dst1 c=1.37148e-15
c624_148 xdut.gndd_p xdut.xpad24.dst1 c=1.37149e-15
c624_147 xdut.gndd_p xdut.xpad24.net424 c=3.01291e-15
c624_146 xdut.gndd_p xdut.net4012 c=1.8046e-15
c624_144 xdut.gndd_p xdut.xpad13.aoutb c=3.86999e-15
c624_143 xdut.gndd_p xdut.net3138 c=4.92751e-15
c624_142 xdut.gndd_p xdut.xpad13.gnstrong c=1.23292e-15
c624_140 xdut.gndd_p xdut.xpad13.gpweak c=1.61241e-15
c624_138 xdut.gndd_p xdut.xpad13.gn c=1.42482e-15
c624_137 xdut.gndd_p xdut.xpad13.xlsgn.o1b c=1.44309e-15
c624_136 xdut.gndd_p xdut.xpad13.xlsgn.o1 c=1.79017e-15
c624_135 xdut.gndd_p xdut.xpad13.gnweak c=1.64454e-15
c624_134 xdut.gndd_p xdut.xpad13.gp c=2.37822e-15
c624_132 xdut.gndd_p xdut.xpad13.xlsgp.o1b c=1.42844e-15
c624_131 xdut.gndd_p xdut.xpad13.xlsgp.o1 c=1.79714e-15
c624_130 xdut.gndd_p xdut.xpad13.ds_ls c=4.58379e-15
c624_129 xdut.gndd_p xdut.xpad13.dsb_ls c=2.94632e-15
c624_128 xdut.gndd_p xdut.xpad13.xlsds.o1b c=1.60037e-15
c624_127 xdut.gndd_p xdut.xpad13.xlsds.o1 c=2.10403e-15
c624_126 xdut.gndd_p xdut.xpad13.xlsie.o1 c=2.15333e-15
c624_125 xdut.gndd_p xdut.xpad13.pd_ls c=5.70712e-15
c624_123 xdut.gndd_p xdut.xpad13.ie_ls c=2.79924e-15
c624_121 xdut.gndd_p xdut.xpad13.xlsie.o1b c=1.51628e-15
c624_118 xdut.gndd_p xdut.xpad13.xlspu.o1b c=1.39387e-15
c624_117 xdut.gndd_p xdut.xpad13.xlspu.o1 c=1.83617e-15
c624_116 xdut.gndd_p xdut.xpad13.xlspd.o1b c=1.46251e-15
c624_115 xdut.gndd_p xdut.xpad13.xlspd.o1 c=1.79295e-15
c624_114 xdut.gndd_p xdut.xpad13.aoutbb c=5.10754e-15
c624_113 xdut.gndd_p xdut.xpad14.gnstrong c=1.23292e-15
c624_112 xdut.gndd_p xdut.xpad14.gnweak c=1.64447e-15
c624_110 xdut.gndd_p xdut.xpad14.gpweak c=1.611e-15
c624_108 xdut.gndd_p xdut.xpad14.gn c=1.42379e-15
c624_107 xdut.gndd_p xdut.xpad14.xlsgn.o1b c=1.44416e-15
c624_106 xdut.gndd_p xdut.xpad14.xlsgn.o1 c=1.79017e-15
c624_105 xdut.gndd_p xdut.xpad14.xlsgp.o1b c=1.42844e-15
c624_104 xdut.gndd_p xdut.xpad14.xlsgp.o1 c=1.79714e-15
c624_103 xdut.gndd_p xdut.xpad14.gp c=2.38055e-15
c624_101 xdut.gndd_p xdut.xpad14.ds_ls c=4.59189e-15
c624_100 xdut.gndd_p xdut.xpad14.dsb_ls c=2.95042e-15
c624_99 xdut.gndd_p xdut.xpad14.xlsds.o1b c=1.60035e-15
c624_98 xdut.gndd_p xdut.xpad14.xlsds.o1 c=2.10419e-15
c624_97 xdut.gndd_p xdut.xpad14.ie_ls c=2.79294e-15
c624_95 xdut.gndd_p xdut.xpad14.xlsie.o1b c=1.51584e-15
c624_94 xdut.gndd_p xdut.xpad14.xlsie.o1 c=2.15333e-15
c624_92 xdut.gndd_p xdut.xpad14.xlspu.o1b c=1.39407e-15
c624_91 xdut.gndd_p xdut.xpad14.xlspu.o1 c=1.83617e-15
c624_90 xdut.gndd_p xdut.xpad14.pd_ls c=5.70427e-15
c624_88 xdut.gndd_p xdut.xpad14.xlspd.o1b c=1.46251e-15
c624_87 xdut.gndd_p xdut.xpad14.xlspd.o1 c=1.79296e-15
c624_86 xdut.gndd_p xdut.xpad14.aoutbb c=5.10829e-15
c624_84 xdut.gndd_p xdut.xpad14.aoutb c=3.86393e-15
c624_82 xdut.gndd_p xdut.net2136 c=4.93004e-15
c624_81 xdut.gndd_p xdut.xpad15.gnstrong c=1.23292e-15
c624_80 xdut.gndd_p xdut.xpad15.gnweak c=1.64484e-15
c624_78 xdut.gndd_p xdut.xpad15.gpweak c=1.61097e-15
c624_76 xdut.gndd_p xdut.xpad15.gn c=1.4232e-15
c624_75 xdut.gndd_p xdut.xpad15.xlsgn.o1b c=1.44416e-15
c624_74 xdut.gndd_p xdut.xpad15.xlsgn.o1 c=1.79017e-15
c624_73 xdut.gndd_p xdut.xpad15.xlsgp.o1b c=1.42845e-15
c624_72 xdut.gndd_p xdut.xpad15.xlsgp.o1 c=1.79714e-15
c624_71 xdut.gndd_p xdut.xpad15.gp c=2.38055e-15
c624_69 xdut.gndd_p xdut.xpad15.ds_ls c=4.58394e-15
c624_68 xdut.gndd_p xdut.xpad15.dsb_ls c=2.94428e-15
c624_67 xdut.gndd_p xdut.xpad15.xlsds.o1b c=1.60036e-15
c624_66 xdut.gndd_p xdut.xpad15.xlsds.o1 c=2.10403e-15
c624_65 xdut.gndd_p xdut.xpad15.ie_ls c=2.79367e-15
c624_63 xdut.gndd_p xdut.xpad15.xlsie.o1b c=1.51449e-15
c624_62 xdut.gndd_p xdut.xpad15.xlsie.o1 c=2.15333e-15
c624_60 xdut.gndd_p xdut.xpad15.xlspu.o1b c=1.39319e-15
c624_59 xdut.gndd_p xdut.xpad15.xlspu.o1 c=1.83617e-15
c624_58 xdut.gndd_p xdut.xpad15.pd_ls c=5.70614e-15
c624_56 xdut.gndd_p xdut.xpad15.xlspd.o1b c=1.46251e-15
c624_55 xdut.gndd_p xdut.xpad15.xlspd.o1 c=1.79296e-15
c624_54 xdut.gndd_p xdut.xpad15.aoutbb c=5.10809e-15
c624_52 xdut.gndd_p xdut.xpad15.aoutb c=3.86383e-15
c624_50 xdut.gndd_p xdut.net2139 c=4.91438e-15
c624_49 xdut.gndd_p xdut.xpad16.gnstrong c=1.23327e-15
c624_48 xdut.gndd_p xdut.xpad16.gnweak c=1.64454e-15
c624_46 xdut.gndd_p xdut.xpad16.gpweak c=1.611e-15
c624_44 xdut.gndd_p xdut.xpad16.gn c=1.42397e-15
c624_43 xdut.gndd_p xdut.xpad16.xlsgn.o1b c=1.44416e-15
c624_42 xdut.gndd_p xdut.xpad16.xlsgn.o1 c=1.79017e-15
c624_41 xdut.gndd_p xdut.xpad16.xlsgp.o1b c=1.42845e-15
c624_40 xdut.gndd_p xdut.xpad16.xlsgp.o1 c=1.79714e-15
c624_39 xdut.gndd_p xdut.xpad16.gp c=2.37968e-15
c624_37 xdut.gndd_p xdut.xpad16.ds_ls c=4.59189e-15
c624_36 xdut.gndd_p xdut.xpad16.dsb_ls c=2.95042e-15
c624_35 xdut.gndd_p xdut.xpad16.xlsds.o1b c=1.60036e-15
c624_34 xdut.gndd_p xdut.xpad16.xlsds.o1 c=2.10403e-15
c624_33 xdut.gndd_p xdut.xpad16.ie_ls c=2.79381e-15
c624_31 xdut.gndd_p xdut.xpad16.xlsie.o1b c=1.51624e-15
c624_30 xdut.gndd_p xdut.xpad16.xlsie.o1 c=2.15333e-15
c624_28 xdut.gndd_p xdut.xpad16.xlspu.o1b c=1.3936e-15
c624_27 xdut.gndd_p xdut.xpad16.xlspu.o1 c=1.8336e-15
c624_26 xdut.gndd_p xdut.xpad16.pd_ls c=5.70495e-15
c624_24 xdut.gndd_p xdut.xpad16.xlspd.o1b c=1.46251e-15
c624_23 xdut.gndd_p xdut.xpad16.xlspd.o1 c=1.79296e-15
c624_22 xdut.gndd_p xdut.xpad16.aoutbb c=5.10797e-15
c624_21 xdut.gndd_p xdut.resb_p c=1.28196e-13
c624_20 xdut.gndd_p xdut.clkref_p c=1.28702e-13
c624_19 xdut.gndd_p xdut.rfc_p c=1.2747e-13
c624_18 xdut.gndd_p xdut.tmode_p c=1.30298e-13
c624_17 xdut.gndd_p xdut.intb_p c=1.31775e-13
c624_16 xdut.gndd_p xdut.dab_p c=1.26771e-13
c624_15 xdut.gndd_p xdut.syncb_p c=1.26879e-13
c624_14 xdut.gndd_p xdut.bfwb_p c=1.2922e-13
c624_13 xdut.gndd_p xdut.csb_p c=1.3695e-13
c624_12 xdut.gndd_p xdut.miso_p c=1.38387e-13
c624_11 xdut.gndd_p xdut.mosi_p c=1.36409e-13
c624_10 xdut.gndd_p xdut.sck_p c=1.34273e-13
c624_9 xdut.gndd_p xdut.aout_p c=6.09286e-13
c624_8 xdut.gndd_p xdut.cldo_p c=1.55558e-15
c624_7 xdut.gndd_p xdut.vsup_p c=9.92053e-14
c624_6 xdut.gndd_p xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd c=1.14506e-13
c624_5 xdut.gndd_p xdut.gnd_p c=3.27499e-12
c624_4 xdut.gndd_p xdut.dgnd_p c=2.816e-12
c624_3 xdut.gndd_p xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=3.83777e-12
c624_2 xdut.gndd_p xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.55017e-11
c624_1 xdut.gndd_p xdut.vio_p c=3.47226e-12
c607_8 xdut.xpad1.gnweak xdut.xpad1.gn c=1.46289e-15
c607_6 xdut.xpad1.gnweak xdut.xpad1.gnstrong c=1.60373e-15
c607_4 xdut.xpad1.gnweak xdut.xpad1.gpweak c=7.46878e-15
c607_3 xdut.xpad1.gnweak xdut.clkref_p c=2.35215e-15
c607_2 xdut.xpad1.gnweak xdut.dgnd_p c=1.09042e-14
c607_1 xdut.xpad1.gnweak xdut.vio_p c=1.12645e-14
c605_8 xdut.xpad1.gpweak xdut.xpad1.gp c=1.49917e-15
c605_4 xdut.xpad1.gpweak xdut.xpad1.gpstrong c=2.80425e-15
c605_3 xdut.xpad1.gpweak xdut.clkref_p c=7.44943e-15
c605_2 xdut.xpad1.gpweak xdut.dgnd_p c=5.23807e-15
c605_1 xdut.xpad1.gpweak xdut.vio_p c=2.04757e-14
cg494_79 xdut.atst_tx<11> 0 c=1.93518e-14
c494_43 xdut.atst_tx<11> xdut.atst_tx<10> c=5.35652e-14
c494_42 xdut.atst_tx<11> xdut.atst_tx<9> c=2.54135e-15
c494_37 xdut.atst_tx<11> xdut.dsi_ok<1> c=2.31977e-15
c494_36 xdut.atst_tx<11> xdut.atst_tx<12> c=5.35854e-14
c494_4 xdut.atst_tx<11> xdut.gnd_dsi c=1.23332e-15
c494_2 xdut.atst_tx<11> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=7.51777e-15
c494_1 xdut.atst_tx<11> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.13927e-15
cg493_77 xdut.atst_tx<10> 0 c=1.48125e-14
c493_46 xdut.atst_tx<10> xdut.atst_tx<9> c=5.34182e-14
c493_45 xdut.atst_tx<10> xdut.atst_tx<8> c=2.3685e-15
c493_40 xdut.atst_tx<10> xdut.atst_tx<12> c=2.23775e-15
c493_4 xdut.atst_tx<10> xdut.gnd_dsi c=1.02887e-15
c493_2 xdut.atst_tx<10> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=6.11746e-15
c493_1 xdut.atst_tx<10> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.14006e-15
cg492_72 xdut.atst_tx<9> 0 c=1.44792e-14
c492_45 xdut.atst_tx<9> xdut.atst_tx<8> c=5.21818e-14
c492_44 xdut.atst_tx<9> xdut.atst_tx<7> c=2.3959e-15
c492_2 xdut.atst_tx<9> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=5.37561e-15
c492_1 xdut.atst_tx<9> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.14289e-15
cg491_65 xdut.atst_tx<8> 0 c=2.11965e-14
c491_42 xdut.atst_tx<8> xdut.atst_tx<7> c=5.11145e-14
c491_2 xdut.atst_tx<8> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=4.52712e-15
c491_1 xdut.atst_tx<8> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.14626e-15
cg490_62 xdut.atst_tx<7> 0 c=3.56051e-14
c490_6 xdut.atst_tx<7> xdut.atst_ts<0> c=4.92283e-15
c490_4 xdut.atst_tx<7> xdut.gnd_dsi c=1.05657e-15
c490_3 xdut.atst_tx<7> xdut.gnd_p c=1.59811e-15
c490_2 xdut.atst_tx<7> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=5.70895e-15
c490_1 xdut.atst_tx<7> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.27546e-15
cg489_85 xdut.dsi_tx_on<1> 0 c=2.40544e-14
c489_47 xdut.dsi_tx_on<1> xdut.xana.net875 c=1.17457e-14
c489_37 xdut.dsi_tx_on<1> xdut.dsi_tx_hvcasc<1> c=5.846e-14
c489_36 xdut.dsi_tx_on<1> xdut.dsi_ok<1> c=2.59855e-15
c489_4 xdut.dsi_tx_on<1> xdut.gnd_dsi c=1.29658e-15
c489_3 xdut.dsi_tx_on<1> xdut.gnd_p c=1.10867e-15
c489_2 xdut.dsi_tx_on<1> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=7.63249e-15
cg488_81 xdut.dsi_tx_hvcasc<1> 0 c=1.45698e-14
c488_37 xdut.dsi_tx_hvcasc<1> xdut.dsi_ok<1> c=5.4959e-14
c488_36 xdut.dsi_tx_hvcasc<1> xdut.atst_tx<12> c=2.3449e-15
c488_4 xdut.dsi_tx_hvcasc<1> xdut.gnd_dsi c=1.28254e-15
c488_2 xdut.dsi_tx_hvcasc<1> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=7.5672e-15
cg487_79 xdut.dsi_ok<1> 0 c=1.92013e-14
c487_47 xdut.dsi_ok<1> xdut.xana.xdsi_ch1<1>.xtx.xtx_lvl_out_0.net130 c=1.0106e-15
c487_36 xdut.dsi_ok<1> xdut.atst_tx<12> c=5.4393e-14
c487_4 xdut.dsi_ok<1> xdut.gnd_dsi c=1.37204e-15
c487_2 xdut.dsi_ok<1> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=7.78778e-15
c487_1 xdut.dsi_ok<1> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.04322e-15
cg486_73 xdut.atst_tx<12> 0 c=1.95128e-14
c486_4 xdut.atst_tx<12> xdut.gnd_dsi c=1.47044e-15
c486_2 xdut.atst_tx<12> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=8.10265e-15
c486_1 xdut.atst_tx<12> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.15239e-15
cg485_91 xdut.dsi_tx_on<0> 0 c=3.05327e-14
c485_44 xdut.dsi_tx_on<0> xdut.xana.net875 c=1.177e-14
c485_34 xdut.dsi_tx_on<0> xdut.dsi_tx_hvcasc<0> c=6.45333e-14
c485_33 xdut.dsi_tx_on<0> xdut.dsi_ok<0> c=2.89742e-15
c485_4 xdut.dsi_tx_on<0> xdut.gnd_dsi c=1.29672e-15
c485_3 xdut.dsi_tx_on<0> xdut.gnd_p c=1.13055e-15
c485_2 xdut.dsi_tx_on<0> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=7.87539e-15
cg484_85 xdut.dsi_tx_hvcasc<0> 0 c=1.63132e-14
c484_33 xdut.dsi_tx_hvcasc<0> xdut.dsi_ok<0> c=6.09065e-14
c484_32 xdut.dsi_tx_hvcasc<0> xdut.atst_tx<5> c=2.58535e-15
c484_4 xdut.dsi_tx_hvcasc<0> xdut.gnd_dsi c=1.2816e-15
c484_2 xdut.dsi_tx_hvcasc<0> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=7.68369e-15
cg483_82 xdut.dsi_ok<0> 0 c=2.10408e-14
c483_45 xdut.dsi_ok<0> xdut.xana.xdsi_ch1<0>.xtx.xtx_lvl_out_0.net130 c=1.01238e-15
c483_32 xdut.dsi_ok<0> xdut.atst_tx<5> c=6.04074e-14
c483_31 xdut.dsi_ok<0> xdut.atst_tx<4> c=2.58346e-15
c483_4 xdut.dsi_ok<0> xdut.gnd_dsi c=1.37328e-15
c483_2 xdut.dsi_ok<0> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=8.07239e-15
c483_1 xdut.dsi_ok<0> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.03618e-15
cg481_76 xdut.atst_tx<5> 0 c=2.11418e-14
c481_31 xdut.atst_tx<5> xdut.atst_tx<4> c=5.93928e-14
c481_30 xdut.atst_tx<5> xdut.atst_tx<3> c=2.5094e-15
c481_4 xdut.atst_tx<5> xdut.gnd_dsi c=1.47346e-15
c481_2 xdut.atst_tx<5> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=8.1654e-15
c481_1 xdut.atst_tx<5> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.15141e-15
cg480_72 xdut.atst_tx<4> 0 c=2.11994e-14
c480_30 xdut.atst_tx<4> xdut.atst_tx<3> c=5.85304e-14
c480_29 xdut.atst_tx<4> xdut.atst_tx<2> c=2.46387e-15
c480_4 xdut.atst_tx<4> xdut.gnd_dsi c=1.2315e-15
c480_2 xdut.atst_tx<4> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=7.59985e-15
c480_1 xdut.atst_tx<4> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.13931e-15
cg479_64 xdut.atst_tx<3> 0 c=2.08232e-14
c479_29 xdut.atst_tx<3> xdut.atst_tx<2> c=5.77047e-14
c479_28 xdut.atst_tx<3> xdut.atst_tx<1> c=2.44951e-15
c479_4 xdut.atst_tx<3> xdut.gnd_dsi c=1.04311e-15
c479_2 xdut.atst_tx<3> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=7.30315e-15
c479_1 xdut.atst_tx<3> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.13893e-15
cg478_58 xdut.atst_tx<2> 0 c=2.02371e-14
c478_28 xdut.atst_tx<2> xdut.atst_tx<1> c=5.74549e-14
c478_27 xdut.atst_tx<2> xdut.atst_tx<0> c=2.36837e-15
c478_2 xdut.atst_tx<2> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=7.07525e-15
c478_1 xdut.atst_tx<2> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.14311e-15
cg477_53 xdut.atst_tx<1> 0 c=1.5354e-14
c477_28 xdut.atst_tx<1> xdut.atst_tx<0> c=5.87065e-14
c477_2 xdut.atst_tx<1> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=6.70523e-15
c477_1 xdut.atst_tx<1> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.14746e-15
cg476_48 xdut.atst_tx<0> 0 c=2.9472e-14
c476_15 xdut.atst_tx<0> xdut.dsi_idac<4> c=1.50301e-14
c476_4 xdut.atst_tx<0> xdut.gnd_dsi c=1.07672e-15
c476_3 xdut.atst_tx<0> xdut.gnd_p c=1.14253e-15
c476_2 xdut.atst_tx<0> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=8.93948e-15
c476_1 xdut.atst_tx<0> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.27424e-15
cg475_56 xdut.dsi_tx_data<4> 0 c=2.31056e-14
c475_45 xdut.dsi_tx_data<4> xdut.dsi_tx_data<3> c=5.66056e-14
c475_25 xdut.dsi_tx_data<4> xdut.dsi_icmp<0> c=4.97711e-14
c475_23 xdut.dsi_tx_data<4> xdut.dsi_idac<0> c=2.05303e-15
c475_14 xdut.dsi_tx_data<4> xdut.dsi_tx_data<2> c=2.48709e-15
c475_4 xdut.dsi_tx_data<4> xdut.gnd_dsi c=1.19291e-15
c475_3 xdut.dsi_tx_data<4> xdut.gnd_p c=1.19366e-15
c475_2 xdut.dsi_tx_data<4> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=7.32435e-15
cg474_59 xdut.dsi_tx_data<3> 0 c=2.24168e-14
c474_54 xdut.dsi_tx_data<3> xdut.xana.xdsi_ch1<0>.xtx.tx_data_5v<4> c=1.0324e-15
c474_43 xdut.dsi_tx_data<3> xdut.dsi_tx_data<1> c=2.60319e-15
c474_24 xdut.dsi_tx_data<3> xdut.dsi_icmp<0> c=2.03996e-15
c474_14 xdut.dsi_tx_data<3> xdut.dsi_tx_data<2> c=5.73799e-14
c474_4 xdut.dsi_tx_data<3> xdut.gnd_dsi c=1.23743e-15
c474_2 xdut.dsi_tx_data<3> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=5.36125e-15
cg473_68 xdut.dsi_tx_data<1> 0 c=1.72868e-14
c473_53 xdut.dsi_tx_data<1> xdut.xana.xdsi_ch1<0>.xtx.tx_data_5v<2> c=1.03362e-15
c473_42 xdut.dsi_tx_data<1> xdut.atst_tx<6> c=3.04582e-15
c473_14 xdut.dsi_tx_data<1> xdut.dsi_tx_data<2> c=5.91167e-14
c473_13 xdut.dsi_tx_data<1> xdut.dsi_tx_data<0> c=6.13534e-14
c473_4 xdut.dsi_tx_data<1> xdut.gnd_dsi c=1.69324e-15
c473_2 xdut.dsi_tx_data<1> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=4.84613e-15
cg472_77 xdut.atst_tx<6> 0 c=2.32035e-14
c472_57 xdut.atst_tx<6> xdut.xana.xdsi_ch1<0>.xtx.tx_data_5v<0> c=1.03471e-15
c472_41 xdut.atst_tx<6> xdut.dsi_tx_tbit_cfg<1> c=6.1685e-14
c472_40 xdut.atst_tx<6> xdut.dsi_tx_tbit_cfg<0> c=3.09493e-15
c472_13 xdut.atst_tx<6> xdut.dsi_tx_data<0> c=6.2559e-14
c472_4 xdut.atst_tx<6> xdut.gnd_dsi c=2.44631e-15
c472_2 xdut.atst_tx<6> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=4.05201e-15
c472_1 xdut.atst_tx<6> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.18323e-15
cg471_88 xdut.dsi_tx_tbit_cfg<1> 0 c=2.63167e-14
c471_41 xdut.dsi_tx_tbit_cfg<1> xdut.dsi_tx_tbit_cfg<0> c=6.28086e-14
c471_40 xdut.dsi_tx_tbit_cfg<1> xdut.dsi_rx_txn<0> c=3.41585e-15
c471_14 xdut.dsi_tx_tbit_cfg<1> xdut.dsi_tx_data<0> c=3.10415e-15
c471_5 xdut.dsi_tx_tbit_cfg<1> xdut.gnd_dsi c=2.60481e-15
c471_2 xdut.dsi_tx_tbit_cfg<1> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=3.98279e-15
cg470_87 xdut.dsi_tx_tbit_cfg<0> 0 c=2.22848e-14
c470_72 xdut.dsi_tx_tbit_cfg<0> xdut.xana.xdsi_ch1<0>.xtx.tx_cfg_5v<1> c=1.01099e-15
c470_40 xdut.dsi_tx_tbit_cfg<0> xdut.dsi_rx_txn<0> c=6.55547e-14
c470_39 xdut.dsi_tx_tbit_cfg<0> xdut.dsi_ov<0> c=2.64925e-15
c470_5 xdut.dsi_tx_tbit_cfg<0> xdut.gnd_dsi c=2.89174e-15
c470_2 xdut.dsi_tx_tbit_cfg<0> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=3.75127e-15
cg469_90 xdut.dsi_rx_txn<0> 0 c=1.33616e-14
c469_73 xdut.dsi_rx_txn<0> xdut.xana.xdsi_ch1<0>.xtx.tx_cfg_5v<0> c=1.03642e-15
c469_39 xdut.dsi_rx_txn<0> xdut.dsi_ov<0> c=5.41055e-14
c469_38 xdut.dsi_rx_txn<0> xdut.dsi_rx_on<0> c=2.50692e-15
c469_5 xdut.dsi_rx_txn<0> xdut.gnd_dsi c=2.78745e-15
c469_3 xdut.dsi_rx_txn<0> xdut.gnd_p c=1.03093e-15
c469_2 xdut.dsi_rx_txn<0> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=5.70563e-15
cg468_95 xdut.dsi_ov<0> 0 c=1.169e-14
c468_48 xdut.dsi_ov<0> xdut.xana.xdsi_ch1<0>.xtx.xtx_lvl_out_ov.net130 c=1.00845e-15
c468_37 xdut.dsi_ov<0> xdut.dsi_rx_on<0> c=4.82001e-14
c468_36 xdut.dsi_ov<0> xdut.atst_rx<0> c=2.49081e-15
c468_3 xdut.dsi_ov<0> xdut.gnd_p c=1.54117e-15
c468_2 xdut.dsi_ov<0> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.17108e-14
c468_1 xdut.dsi_ov<0> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=2.86644e-15
cg467_44 xdut.dsi_rx_on<0> 0 c=1.86581e-14
c467_37 xdut.dsi_rx_on<0> xdut.atst_rx<0> c=6.76993e-14
c467_36 xdut.dsi_rx_on<0> xdut.trim_dsi_rx1<3> c=3.40134e-15
c467_4 xdut.dsi_rx_on<0> xdut.gnd_dsi c=1.03487e-15
c467_3 xdut.dsi_rx_on<0> xdut.gnd_p c=2.02337e-15
c467_2 xdut.dsi_rx_on<0> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=6.69419e-15
cg466_44 xdut.atst_rx<0> 0 c=1.68814e-14
c466_37 xdut.atst_rx<0> xdut.trim_dsi_rx1<3> c=6.73845e-14
c466_36 xdut.atst_rx<0> xdut.trim_dsi_rx1<2> c=3.50529e-15
c466_4 xdut.atst_rx<0> xdut.gnd_dsi c=7.1165e-15
c466_3 xdut.atst_rx<0> xdut.gnd_p c=1.5548e-15
c466_2 xdut.atst_rx<0> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=9.30285e-15
c466_1 xdut.atst_rx<0> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=4.12464e-15
cg465_42 xdut.trim_dsi_rx1<3> 0 c=1.5012e-14
c465_35 xdut.trim_dsi_rx1<3> xdut.trim_dsi_rx1<2> c=6.75066e-14
c465_34 xdut.trim_dsi_rx1<3> xdut.trim_dsi_rx1<1> c=3.44016e-15
c465_4 xdut.trim_dsi_rx1<3> xdut.gnd_dsi c=1.01618e-15
c465_3 xdut.trim_dsi_rx1<3> xdut.gnd_p c=1.56162e-15
c465_2 xdut.trim_dsi_rx1<3> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=6.82592e-15
cg464_41 xdut.trim_dsi_rx1<2> 0 c=1.48152e-14
c464_34 xdut.trim_dsi_rx1<2> xdut.trim_dsi_rx1<1> c=6.76686e-14
c464_33 xdut.trim_dsi_rx1<2> xdut.trim_dsi_rx1<0> c=3.45583e-15
c464_3 xdut.trim_dsi_rx1<2> xdut.gnd_p c=1.60187e-15
c464_2 xdut.trim_dsi_rx1<2> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=6.92755e-15
cg462_40 xdut.trim_dsi_rx1<1> 0 c=1.50615e-14
c462_33 xdut.trim_dsi_rx1<1> xdut.trim_dsi_rx1<0> c=6.77159e-14
c462_32 xdut.trim_dsi_rx1<1> xdut.trim_dsi_rx2<3> c=3.37958e-15
c462_3 xdut.trim_dsi_rx1<1> xdut.gnd_p c=1.57083e-15
c462_2 xdut.trim_dsi_rx1<1> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=6.82613e-15
cg461_39 xdut.trim_dsi_rx1<0> 0 c=1.5282e-14
c461_32 xdut.trim_dsi_rx1<0> xdut.trim_dsi_rx2<3> c=6.76859e-14
c461_31 xdut.trim_dsi_rx1<0> xdut.trim_dsi_rx2<2> c=3.29519e-15
c461_3 xdut.trim_dsi_rx1<0> xdut.gnd_p c=1.6814e-15
c461_2 xdut.trim_dsi_rx1<0> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=6.68262e-15
cg460_38 xdut.trim_dsi_rx2<3> 0 c=1.56349e-14
c460_31 xdut.trim_dsi_rx2<3> xdut.trim_dsi_rx2<2> c=6.75629e-14
c460_30 xdut.trim_dsi_rx2<3> xdut.trim_dsi_rx2<1> c=3.28084e-15
c460_4 xdut.trim_dsi_rx2<3> xdut.gnd_dsi c=1.01596e-15
c460_3 xdut.trim_dsi_rx2<3> xdut.gnd_p c=1.57048e-15
c460_2 xdut.trim_dsi_rx2<3> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=6.72309e-15
cg459_37 xdut.trim_dsi_rx2<2> 0 c=1.57017e-14
c459_30 xdut.trim_dsi_rx2<2> xdut.trim_dsi_rx2<1> c=6.74149e-14
c459_29 xdut.trim_dsi_rx2<2> xdut.trim_dsi_rx2<0> c=3.63512e-15
c459_4 xdut.trim_dsi_rx2<2> xdut.gnd_dsi c=1.0187e-15
c459_3 xdut.trim_dsi_rx2<2> xdut.gnd_p c=1.56767e-15
c459_2 xdut.trim_dsi_rx2<2> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=6.39521e-15
cg458_36 xdut.trim_dsi_rx2<1> 0 c=1.45995e-14
c458_29 xdut.trim_dsi_rx2<1> xdut.trim_dsi_rx2<0> c=6.77265e-14
c458_27 xdut.trim_dsi_rx2<1> xdut.dsi_rxd1<0> c=4.03757e-15
c458_3 xdut.trim_dsi_rx2<1> xdut.gnd_p c=2.22985e-15
c458_2 xdut.trim_dsi_rx2<1> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=6.50773e-15
cg457_35 xdut.trim_dsi_rx2<0> 0 c=9.96289e-15
c457_27 xdut.trim_dsi_rx2<0> xdut.dsi_rxd1<0> c=6.80268e-14
c457_26 xdut.trim_dsi_rx2<0> xdut.dsi_rxd2<0> c=4.24536e-15
c457_3 xdut.trim_dsi_rx2<0> xdut.gnd_p c=1.66574e-15
c457_2 xdut.trim_dsi_rx2<0> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=8.59352e-15
cg456_31 xdut.dsi_rx_filter_fast<0> 0 c=2.53243e-15
c456_24 xdut.dsi_rx_filter_fast<0> xdut.dsi_rxd1<0> c=3.98608e-15
c456_23 xdut.dsi_rx_filter_fast<0> xdut.dsi_rxd2<0> c=5.96092e-14
c456_4 xdut.dsi_rx_filter_fast<0> xdut.gnd_dsi c=1.1098e-15
c456_3 xdut.dsi_rx_filter_fast<0> xdut.gnd_p c=1.8074e-15
c456_2 xdut.dsi_rx_filter_fast<0> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.21474e-14
cg455_30 xdut.dsi_rxd1<0> 0 c=4.84066e-15
c455_27 xdut.dsi_rxd1<0> xdut.xana.xdsi_ch1<0>.xrx.net719 c=1.004e-15
c455_26 xdut.dsi_rxd1<0> xdut.dsi_rxd2<0> c=6.79423e-14
c455_4 xdut.dsi_rxd1<0> xdut.gnd_dsi c=1.0614e-15
c455_3 xdut.dsi_rxd1<0> xdut.gnd_p c=1.69028e-15
c455_2 xdut.dsi_rxd1<0> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=9.9929e-15
c455_1 xdut.dsi_rxd1<0> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=2.32209e-15
cg454_28 xdut.dsi_rxd2<0> 0 c=2.83926e-15
c454_27 xdut.dsi_rxd2<0> xdut.xana.xdsi_ch1<0>.xrx.net718 c=1.00017e-15
c454_4 xdut.dsi_rxd2<0> xdut.gnd_dsi c=1.1529e-15
c454_3 xdut.dsi_rxd2<0> xdut.gnd_p c=1.75363e-15
c454_2 xdut.dsi_rxd2<0> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.197e-14
c454_1 xdut.dsi_rxd2<0> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=2.37367e-15
cg412_23 xdut.net3316 0 c=1.49392e-14
c412_2 xdut.net3316 xdut.clkref_p c=6.6455e-15
c412_1 xdut.net3316 xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=2.13852e-15
cg407_24 xdut.sdo_o 0 c=5.88332e-15
c407_16 xdut.sdo_o xdut.sdo_i c=2.43008e-14
c407_15 xdut.sdo_o xdut.sdo_ie c=1.42428e-15
c407_12 xdut.sdo_o xdut.sdo_oe c=2.48952e-14
c407_3 xdut.sdo_o xdut.miso_p c=2.72436e-15
c407_2 xdut.sdo_o xdut.mosi_p c=2.67057e-15
cg406_17 xdut.sdo_i 0 c=6.18868e-15
c406_15 xdut.sdo_i xdut.sdo_ie c=2.42638e-14
c406_14 xdut.sdo_i xdut.sdo_pd c=1.41157e-15
c406_12 xdut.sdo_i xdut.sdo_oe c=1.46695e-15
c406_3 xdut.sdo_i xdut.miso_p c=2.73098e-15
c406_2 xdut.sdo_i xdut.mosi_p c=2.66252e-15
c406_1 xdut.sdo_i xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.35786e-15
cg405_18 xdut.sdo_ie 0 c=6.05155e-15
c405_14 xdut.sdo_ie xdut.sdo_pd c=2.42581e-14
c405_13 xdut.sdo_ie xdut.sdo_pu c=1.42331e-15
c405_3 xdut.sdo_ie xdut.miso_p c=2.67651e-15
c405_2 xdut.sdo_ie xdut.mosi_p c=2.63832e-15
cg404_20 xdut.sdo_pd 0 c=6.34359e-15
c404_19 xdut.sdo_pd xdut.xpad21.pdb c=1.03123e-15
c404_13 xdut.sdo_pd xdut.sdo_pu c=2.50127e-14
c404_3 xdut.sdo_pd xdut.miso_p c=2.69535e-15
c404_2 xdut.sdo_pd xdut.mosi_p c=2.6465e-15
cg403_18 xdut.sdo_pu 0 c=1.28848e-14
c403_3 xdut.sdo_pu xdut.miso_p c=4.0593e-15
c403_2 xdut.sdo_pu xdut.mosi_p c=4.17753e-15
cg402_16 xdut.sdo_oe 0 c=1.03949e-14
c402_11 xdut.sdo_oe xdut.sdi_pu c=8.15078e-15
c402_3 xdut.sdo_oe xdut.miso_p c=4.2031e-15
c402_2 xdut.sdo_oe xdut.mosi_p c=2.85932e-15
cg363_36 xdut.dsi_icmp<0> 0 c=3.44485e-14
c363_25 xdut.dsi_icmp<0> xdut.dsi_idac<0> c=7.13799e-14
c363_24 xdut.dsi_icmp<0> xdut.dsi_idac<1> c=2.93048e-15
c363_4 xdut.dsi_icmp<0> xdut.gnd_dsi c=1.10445e-15
c363_3 xdut.dsi_icmp<0> xdut.gnd_p c=1.97318e-15
c363_2 xdut.dsi_icmp<0> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=8.00812e-15
c363_1 xdut.dsi_icmp<0> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.94838e-15
cg362_36 xdut.dsi_idac<3> 0 c=3.11784e-14
c362_21 xdut.dsi_idac<3> xdut.dsi_idac<1> c=3.94507e-15
c362_20 xdut.dsi_idac<3> xdut.dsi_idac<2> c=8.71129e-14
c362_17 xdut.dsi_idac<3> xdut.dsi_idac<4> c=8.61232e-14
c362_4 xdut.dsi_idac<3> xdut.gnd_dsi c=1.16698e-15
c362_2 xdut.dsi_idac<3> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=6.23881e-15
c362_1 xdut.dsi_idac<3> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.44395e-15
cg361_44 xdut.dsi_idac<0> 0 c=3.59065e-14
c361_33 xdut.dsi_idac<0> xdut.xana.xdsi_ch1<0>.xrx.idac2atb_5v c=1.27928e-15
c361_21 xdut.dsi_idac<0> xdut.dsi_idac<1> c=9.75733e-14
c361_20 xdut.dsi_idac<0> xdut.dsi_idac<2> c=4.2262e-15
c361_4 xdut.dsi_idac<0> xdut.gnd_dsi c=1.42508e-15
c361_3 xdut.dsi_idac<0> xdut.gnd_p c=1.35952e-14
c361_2 xdut.dsi_idac<0> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=5.74798e-15
c361_1 xdut.dsi_idac<0> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.51248e-15
cg360_41 xdut.dsi_idac<1> 0 c=2.57317e-14
c360_20 xdut.dsi_idac<1> xdut.dsi_idac<2> c=9.70073e-14
c360_3 xdut.dsi_idac<1> xdut.gnd_p c=2.18402e-15
c360_2 xdut.dsi_idac<1> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=5.66532e-15
c360_1 xdut.dsi_idac<1> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.16299e-15
cg359_34 xdut.dsi_idac<2> 0 c=2.62432e-14
c359_17 xdut.dsi_idac<2> xdut.dsi_idac<4> c=4.32132e-15
c359_4 xdut.dsi_idac<2> xdut.gnd_dsi c=1.67392e-15
c359_3 xdut.dsi_idac<2> xdut.gnd_p c=1.51852e-15
c359_2 xdut.dsi_idac<2> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=6.17229e-15
c359_1 xdut.dsi_idac<2> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.3941e-15
cg356_11 xdut.trim_osc_f<4> 0 c=2.12912e-15
c356_9 xdut.trim_osc_f<4> xdut.trim_osc_f<2> c=1.57506e-15
c356_8 xdut.trim_osc_f<4> xdut.trim_osc_f<5> c=1.97418e-14
c356_7 xdut.trim_osc_f<4> xdut.trim_osc_f<3> c=1.97611e-14
c356_5 xdut.trim_osc_f<4> xdut.trim_osc_f<6> c=1.86217e-15
cg355_9 xdut.trim_osc_f<2> 0 c=2.60883e-15
c355_7 xdut.trim_osc_f<2> xdut.trim_osc_f<3> c=1.98305e-14
c355_6 xdut.trim_osc_f<2> xdut.trim_osc_f<0> c=1.86951e-15
c355_4 xdut.trim_osc_f<2> xdut.trim_osc_f<1> c=1.98399e-14
cg354_9 xdut.trim_osc_f<5> 0 c=2.03679e-15
c354_7 xdut.trim_osc_f<5> xdut.trim_osc_f<3> c=1.34615e-15
c354_5 xdut.trim_osc_f<5> xdut.trim_osc_f<6> c=2.03014e-14
cg353_8 xdut.trim_osc_f<3> 0 c=2.03654e-15
c353_4 xdut.trim_osc_f<3> xdut.trim_osc_f<1> c=1.57402e-15
cg352_6 xdut.trim_osc_f<0> 0 c=2.11897e-15
c352_4 xdut.trim_osc_f<0> xdut.trim_osc_f<1> c=1.97675e-14
cg351_8 xdut.trim_osc_f<6> 0 c=1.94974e-15
c351_7 xdut.trim_osc_f<6> xdut.xosc.xosc_20m_0.xosc20m_0.xdecoder.sb<6> c=1.69752e-15
cg350_5 xdut.trim_osc_f<1> 0 c=2.17757e-15
cg349_147 xdut.vdd_nbl 0 c=2.07761e-13
c349_1 xdut.vdd_nbl xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=7.15999e-14
cg344_33 xdut.por_1v8 0 c=5.29133e-14
c344_32 xdut.por_1v8 xdut.xpad1.pdb c=1.02586e-15
c344_20 xdut.por_1v8 xdut.clkref_i c=1.87568e-15
c344_19 xdut.por_1v8 xdut.clkref_ie c=2.67399e-14
c344_17 xdut.por_1v8 xdut.tmode_i c=2.24965e-14
c344_16 xdut.por_1v8 xdut.por_n c=2.25843e-14
c344_9 xdut.por_1v8 xdut.vcc_ok c=2.08845e-14
c344_4 xdut.por_1v8 xdut.clkref_p c=1.28047e-15
c344_3 xdut.por_1v8 xdut.gnd_p c=7.50473e-15
c344_2 xdut.por_1v8 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.025e-15
c344_1 xdut.por_1v8 xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=8.1678e-15
cg337_82 xdut.otp_vrr 0 c=2.2134e-13
c337_79 xdut.otp_vrr xdut.xana.xsup.xvrrmon.vrr_int c=7.80327e-15
c337_74 xdut.otp_vrr xdut.xana.xsup.atst_sup_5v<4> c=2.94408e-15
c337_63 xdut.otp_vrr xdut.xana.xotpmux.vbn1 c=1.20499e-15
c337_57 xdut.otp_vrr xdut.xana.xotpmux.xsw2.net28 c=1.22089e-15
c337_22 xdut.otp_vrr xdut.otp_vref c=3.28222e-15
c337_17 xdut.otp_vrr xdut.otp_vpp c=9.05363e-15
c337_6 xdut.otp_vrr xdut.aout_int c=8.85003e-15
c337_3 xdut.otp_vrr xdut.gnd_p c=5.13937e-13
c337_2 xdut.otp_vrr xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.2265e-14
c337_1 xdut.otp_vrr xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=8.35022e-15
cg335_20 xdut.otp_vref 0 c=1.19792e-13
c335_15 xdut.otp_vref xdut.xana.xotpmux.xsw1.net28 c=1.21956e-15
c335_7 xdut.otp_vref xdut.otp_ehv c=5.05903e-15
c335_5 xdut.otp_vref xdut.otp_vpp c=1.24256e-15
c335_3 xdut.otp_vref xdut.gnd_p c=1.77644e-13
c335_2 xdut.otp_vref xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=2.3782e-15
c335_1 xdut.otp_vref xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=2.03089e-15
cg333_30 xdut.dsi_idac<4> 0 c=5.37625e-14
c333_15 xdut.dsi_idac<4> xdut.ldo_ok c=8.60532e-15
c333_4 xdut.dsi_idac<4> xdut.gnd_dsi c=1.13842e-15
c333_3 xdut.dsi_idac<4> xdut.gnd_p c=1.2506e-15
c333_2 xdut.dsi_idac<4> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=7.55312e-15
c333_1 xdut.dsi_idac<4> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.43426e-15
cg330_76 xdut.pll_ic5u 0 c=2.74557e-14
c330_71 xdut.pll_ic5u xdut.xosc.xpll_top_0.xpll_core_0.xchp_off_0.net113 c=1.10498e-15
c330_69 xdut.pll_ic5u xdut.xosc.xpll_top_0.xpll_core_0.xchp_off_0.net57 c=3.35843e-15
c330_68 xdut.pll_ic5u xdut.xosc.xpll_top_0.xpll_core_0.xchp_off_0.net47 c=2.41829e-15
c330_53 xdut.pll_ic5u xdut.xosc.xpll_top_0.xpll_core_0.pd_n c=2.35347e-15
c330_45 xdut.pll_ic5u xdut.xosc.xpll_top_0.xpll_core_0.vctrl c=1.37708e-15
c330_1 xdut.pll_ic5u xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=3.28932e-14
cg326_11 xdut.otp_ehv 0 c=2.38807e-14
c326_5 xdut.otp_ehv xdut.otp_ehv_1v8 c=5.18019e-15
c326_3 xdut.otp_ehv xdut.gnd_p c=1.85881e-13
c326_2 xdut.otp_ehv xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=3.45456e-15
c326_1 xdut.otp_ehv xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.81011e-14
cg325_11 xdut.otp_ehv_1v8 0 c=5.47704e-14
c325_3 xdut.otp_ehv_1v8 xdut.gnd_p c=9.36271e-14
c325_2 xdut.otp_ehv_1v8 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=4.58509e-15
c325_1 xdut.otp_ehv_1v8 xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=3.40938e-14
cg324_25 xdut.otp_vpp 0 c=6.94041e-14
c324_16 xdut.otp_vpp xdut.xana.xotpmux.net273 c=3.38811e-15
c324_4 xdut.otp_vpp xdut.xana.xotpmux.dm11c c=1.39488e-15
c324_3 xdut.otp_vpp xdut.gnd_p c=1.26933e-13
c324_2 xdut.otp_vpp xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.82545e-15
c324_1 xdut.otp_vpp xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=2.49416e-15
cg322_28 xdut.ldo_en 0 c=2.60849e-14
c322_19 xdut.ldo_en xdut.xana.net875 c=1.26759e-15
c322_18 xdut.ldo_en xdut.ldo_ok c=8.58921e-14
c322_14 xdut.ldo_en xdut.en_atb c=1.07306e-13
c322_5 xdut.ldo_en xdut.aout_p c=1.00737e-15
c322_3 xdut.ldo_en xdut.gnd_p c=4.69577e-15
c322_2 xdut.ldo_en xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.16308e-14
c322_1 xdut.ldo_en xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=2.46677e-15
cg317_23 xdut.ldo_ok 0 c=4.42733e-14
c317_16 xdut.ldo_ok xdut.xana.net875 c=9.37102e-15
c317_12 xdut.ldo_ok xdut.en_atb c=7.68223e-15
c317_3 xdut.ldo_ok xdut.gnd_p c=1.43018e-14
c317_2 xdut.ldo_ok xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.30085e-14
c317_1 xdut.ldo_ok xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=2.0981e-15
cg315_35 xdut.dsi_tx_data<2> 0 c=2.25844e-14
c315_26 xdut.dsi_tx_data<2> xdut.xana.xdsi_ch1<0>.xtx.tx_data_5v<3> c=1.01461e-15
c315_13 xdut.dsi_tx_data<2> xdut.dsi_tx_data<0> c=3.09338e-15
c315_4 xdut.dsi_tx_data<2> xdut.gnd_dsi c=1.43922e-15
c315_2 xdut.dsi_tx_data<2> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=5.49105e-15
cg314_44 xdut.dsi_tx_data<0> 0 c=1.64969e-14
c314_27 xdut.dsi_tx_data<0> xdut.xana.xdsi_ch1<0>.xtx.tx_data_5v<1> c=1.04503e-15
c314_4 xdut.dsi_tx_data<0> xdut.gnd_dsi c=2.03969e-15
c314_2 xdut.dsi_tx_data<0> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=4.53089e-15
cg313_26 xdut.atst_osc<1> 0 c=3.5783e-14
c313_18 xdut.atst_osc<1> xdut.xosc.xosc_20m_0.xosc20m_0.abus_enb c=1.02876e-15
c313_13 xdut.atst_osc<1> xdut.atst_osc<0> c=5.78348e-14
c313_12 xdut.atst_osc<1> xdut.atst_osc<2> c=3.91391e-15
c313_10 xdut.atst_osc<1> xdut.trim_osc_tcf<1> c=2.57898e-15
c313_9 xdut.atst_osc<1> xdut.trim_osc_tcf<0> c=2.8771e-14
c313_1 xdut.atst_osc<1> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=3.08957e-15
cg312_27 xdut.atst_osc<0> 0 c=1.25084e-14
c312_12 xdut.atst_osc<0> xdut.atst_osc<2> c=5.12143e-14
c312_9 xdut.atst_osc<0> xdut.trim_osc_tcf<0> c=2.22039e-15
c312_8 xdut.atst_osc<0> xdut.osc_ready c=1.89468e-15
c312_1 xdut.atst_osc<0> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=2.69174e-15
cg311_30 xdut.atst_osc<2> 0 c=1.37652e-14
c311_22 xdut.atst_osc<2> xdut.xosc.xosc_20m_0.xosc20m_0.net173 c=1.09406e-15
c311_21 xdut.atst_osc<2> xdut.xosc.xosc_20m_0.xosc20m_0.abus_enb c=2.71216e-15
c311_11 xdut.atst_osc<2> xdut.osc_ready c=2.98894e-14
c311_10 xdut.atst_osc<2> xdut.clkosc c=1.89021e-15
c311_1 xdut.atst_osc<2> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=3.36508e-15
cg310_33 xdut.trim_osc_tcf<2> 0 c=5.53456e-15
c310_26 xdut.trim_osc_tcf<2> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.sb<0> c=1.71219e-15
c310_25 xdut.trim_osc_tcf<2> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.sb<2> c=1.03311e-15
c310_24 xdut.trim_osc_tcf<2> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.sb<1> c=1.95244e-15
c310_11 xdut.trim_osc_tcf<2> xdut.trim_osc_tcf<1> c=6.19373e-14
c310_10 xdut.trim_osc_tcf<2> xdut.trim_osc_tcf<0> c=5.61521e-15
cg309_34 xdut.trim_osc_tcf<1> 0 c=4.68581e-15
c309_25 xdut.trim_osc_tcf<1> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.sb<0> c=1.99272e-15
c309_24 xdut.trim_osc_tcf<1> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.sb<2> c=2.5151e-15
c309_23 xdut.trim_osc_tcf<1> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.sb<1> c=1.0379e-15
c309_10 xdut.trim_osc_tcf<1> xdut.trim_osc_tcf<0> c=5.93502e-14
cg308_27 xdut.trim_osc_tcf<0> 0 c=9.99028e-15
c308_22 xdut.trim_osc_tcf<0> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.sb<0> c=1.89342e-15
c308_20 xdut.trim_osc_tcf<0> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.sb<1> c=3.48305e-15
cg306_13 xdut.osc_ready 0 c=1.02052e-14
c306_7 xdut.osc_ready xdut.clkosc c=2.8479e-14
c306_6 xdut.osc_ready xdut.clkref_filt c=1.9625e-15
c306_1 xdut.osc_ready xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.81054e-15
cg305_17 xdut.clkosc 0 c=1.02962e-14
c305_9 xdut.clkosc xdut.xosc.xosc_20m_0.xosc20m_0.net400 c=1.27462e-15
c305_8 xdut.clkosc xdut.clkref_filt c=2.85873e-14
c305_5 xdut.clkosc xdut.clkref_pll c=1.90438e-15
c305_1 xdut.clkosc xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=5.74762e-15
cg304_10 xdut.clkref_filt 0 c=1.1904e-14
c304_6 xdut.clkref_filt xdut.clkpll c=2.15364e-15
c304_5 xdut.clkref_filt xdut.clkref_pll c=2.84079e-14
c304_1 xdut.clkref_filt xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=2.29205e-15
cg302_22 xdut.osc_on 0 c=3.81167e-14
c302_20 xdut.osc_on xdut.atst_pll<6> c=7.6036e-15
c302_10 xdut.osc_on xdut.clkpll c=3.1898e-14
c302_7 xdut.osc_on xdut.clkref_pll c=2.00919e-15
c302_6 xdut.osc_on xdut.clkref_i c=2.85902e-14
cg301_33 xdut.atst_pll<6> 0 c=3.85574e-14
c301_20 xdut.atst_pll<6> xdut.atst_pll<5> c=5.34804e-14
c301_19 xdut.atst_pll<6> xdut.atst_pll<4> c=3.05883e-15
cg300_34 xdut.atst_pll<5> 0 c=2.45415e-14
c300_19 xdut.atst_pll<5> xdut.atst_pll<4> c=5.5254e-14
c300_18 xdut.atst_pll<5> xdut.atst_pll<3> c=3.02184e-15
cg299_33 xdut.atst_pll<4> 0 c=2.43805e-14
c299_18 xdut.atst_pll<4> xdut.atst_pll<3> c=5.21504e-14
c299_17 xdut.atst_pll<4> xdut.atst_pll<2> c=2.90583e-15
cg298_33 xdut.atst_pll<3> 0 c=2.43083e-14
c298_17 xdut.atst_pll<3> xdut.atst_pll<2> c=5.51758e-14
c298_12 xdut.atst_pll<3> xdut.atst_pll<1> c=2.87315e-15
cg297_32 xdut.atst_pll<2> 0 c=2.44616e-14
c297_13 xdut.atst_pll<2> xdut.atst_pll<0> c=2.90056e-15
c297_12 xdut.atst_pll<2> xdut.atst_pll<1> c=5.19327e-14
cg296_26 xdut.pll_hold 0 c=2.32647e-14
c296_15 xdut.pll_hold xdut.pll_down_mon c=4.94698e-14
c296_14 xdut.pll_hold xdut.pll_lock_mon c=2.67932e-15
c296_10 xdut.pll_hold xdut.clkpll_div c=2.8494e-15
c296_9 xdut.pll_hold xdut.pll_up_mon c=4.96004e-14
cg294_33 xdut.pll_down_mon 0 c=2.50522e-14
c294_14 xdut.pll_down_mon xdut.pll_lock_mon c=5.23194e-14
c294_13 xdut.pll_down_mon xdut.atst_pll<0> c=2.90301e-15
c294_9 xdut.pll_down_mon xdut.pll_up_mon c=2.81694e-15
cg293_36 xdut.pll_lock_mon 0 c=2.43229e-14
c293_13 xdut.pll_lock_mon xdut.atst_pll<0> c=5.20721e-14
c293_12 xdut.pll_lock_mon xdut.atst_pll<1> c=2.94895e-15
cg292_30 xdut.atst_pll<0> 0 c=2.41951e-14
c292_12 xdut.atst_pll<0> xdut.atst_pll<1> c=5.51782e-14
cg291_29 xdut.atst_pll<1> 0 c=2.44034e-14
cg290_63 xdut.clkpll 0 c=2.48778e-14
c290_8 xdut.clkpll xdut.pll_on c=1.48948e-14
c290_7 xdut.clkpll xdut.clkref_pll c=5.74034e-14
c290_6 xdut.clkpll xdut.clkref_i c=3.14103e-14
c290_1 xdut.clkpll xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=2.79493e-15
cg289_57 xdut.clkpll_div 0 c=3.29961e-14
c289_10 xdut.clkpll_div xdut.pll_up_mon c=5.01773e-14
c289_9 xdut.clkpll_div xdut.pll_on c=1.71857e-14
c289_7 xdut.clkpll_div xdut.clkref_pll c=2.04231e-15
c289_2 xdut.clkpll_div xdut.gnd_p c=1.28159e-15
c289_1 xdut.clkpll_div xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.79793e-15
cg288_27 xdut.pll_up_mon 0 c=2.42374e-14
c288_8 xdut.pll_up_mon xdut.pll_on c=1.8152e-15
cg287_64 xdut.pll_on 0 c=5.82015e-14
c287_29 xdut.pll_on xdut.xosc.xpll_top_0.xcco_0.net56 c=1.33465e-15
c287_5 xdut.pll_on xdut.por_n c=1.06846e-15
c287_2 xdut.pll_on xdut.gnd_p c=4.00687e-14
c287_1 xdut.pll_on xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.01888e-14
cg286_25 xdut.atst_sup<0> 0 c=3.14425e-14
c286_18 xdut.atst_sup<0> xdut.vdd_rdiv_dis c=7.78529e-14
c286_17 xdut.atst_sup<0> xdut.vdd_iload_dis c=4.07801e-15
c286_5 xdut.atst_sup<0> xdut.atst_sup<2> c=4.35232e-15
c286_4 xdut.atst_sup<0> xdut.atst_sup<1> c=7.80834e-14
c286_3 xdut.atst_sup<0> xdut.gnd_p c=3.15872e-15
c286_1 xdut.atst_sup<0> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.26785e-15
cg285_54 xdut.vdd_rdiv_dis 0 c=3.90389e-14
c285_18 xdut.vdd_rdiv_dis xdut.vdd_iload_dis c=1.23547e-13
c285_5 xdut.vdd_rdiv_dis xdut.atst_sup<1> c=4.65243e-15
c285_3 xdut.vdd_rdiv_dis xdut.gnd_p c=1.37889e-14
c285_2 xdut.vdd_rdiv_dis xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.20067e-15
cg284_49 xdut.vdd_iload_dis 0 c=5.13463e-14
c284_42 xdut.vdd_iload_dis xdut.xana.xsup.xvddreg.rdiv<33> c=2.48412e-15
c284_3 xdut.vdd_iload_dis xdut.gnd_p c=5.7346e-14
cg283_20 xdut.clkref_pll 0 c=2.26957e-14
c283_6 xdut.clkref_pll xdut.clkref_i c=2.17164e-15
cg282_22 xdut.clkref_i 0 c=4.94126e-14
c282_17 xdut.clkref_i xdut.xosc.xclkref_lpf_0.vdd_rc c=5.75869e-15
c282_11 xdut.clkref_i xdut.xosc.xclkref_lpf_0.rci c=1.26473e-15
c282_9 xdut.clkref_i xdut.clkref_ie c=3.73961e-14
c282_8 xdut.clkref_i xdut.pad_ds c=2.75841e-14
c282_7 xdut.clkref_i xdut.tmode_i c=1.92466e-15
c282_4 xdut.clkref_i xdut.clkref_p c=1.32534e-15
c282_1 xdut.clkref_i xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=3.36829e-15
cg281_21 xdut.clkref_ie 0 c=6.30348e-14
c281_18 xdut.clkref_ie xdut.pad_ds c=8.1962e-14
c281_15 xdut.clkref_ie xdut.vrr_ok c=4.81438e-15
c281_5 xdut.clkref_ie xdut.reg_vdd_dis c=3.83012e-15
c281_4 xdut.clkref_ie xdut.clkref_p c=1.31459e-15
c281_1 xdut.clkref_ie xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=4.65173e-15
cg280_129 xdut.pad_ds 0 c=3.0661e-13
c280_85 xdut.pad_ds xdut.xana.xsup.xvbgbuf.vcc_nbl c=1.51796e-15
c280_69 xdut.pad_ds xdut.net3137 c=1.03565e-15
c280_45 xdut.pad_ds xdut.sdi_oe c=5.6373e-15
c280_44 xdut.pad_ds xdut.sck_pu c=1.04845e-14
c280_31 xdut.pad_ds xdut.tmode_i c=4.64571e-14
c280_19 xdut.pad_ds xdut.reg_vdd_dis c=6.22706e-14
c280_16 xdut.pad_ds xdut.resb_p c=1.94542e-15
c280_15 xdut.pad_ds xdut.clkref_p c=1.33924e-15
c280_14 xdut.pad_ds xdut.rfc_p c=1.98442e-15
c280_13 xdut.pad_ds xdut.intb_p c=1.7146e-15
c280_12 xdut.pad_ds xdut.dab_p c=1.88576e-15
c280_11 xdut.pad_ds xdut.syncb_p c=1.90843e-15
c280_10 xdut.pad_ds xdut.bfwb_p c=3.40069e-15
c280_9 xdut.pad_ds xdut.csb_p c=6.59017e-15
c280_8 xdut.pad_ds xdut.miso_p c=9.88812e-15
c280_7 xdut.pad_ds xdut.mosi_p c=8.60527e-15
c280_6 xdut.pad_ds xdut.sck_p c=8.79142e-15
c280_4 xdut.pad_ds xdut.dgnd_p c=9.38486e-15
c280_2 xdut.pad_ds xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=2.11316e-14
c280_1 xdut.pad_ds xdut.vio_p c=1.003e-14
cg279_20 xdut.tmode_i 0 c=8.32598e-14
c279_17 xdut.tmode_i xdut.xana.xsup.xvbgbuf.vcc_nbl c=3.00582e-15
c279_15 xdut.tmode_i xdut.por_n c=5.99333e-14
c279_14 xdut.tmode_i xdut.vrr_ok c=3.3814e-15
c279_9 xdut.tmode_i xdut.trim_i5u<3> c=3.33233e-15
c279_8 xdut.tmode_i xdut.vcc_ok c=5.96938e-14
c279_4 xdut.tmode_i xdut.tmode_p c=1.31134e-15
c279_3 xdut.tmode_i xdut.gnd_p c=2.18794e-15
c279_1 xdut.tmode_i xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=5.1426e-15
cg278_24 xdut.por_n 0 c=2.98732e-14
c278_14 xdut.por_n xdut.vrr_ok c=8.49307e-14
c278_8 xdut.por_n xdut.vcc_ok c=4.3017e-15
c278_3 xdut.por_n xdut.gnd_p c=6.24091e-15
c278_1 xdut.por_n xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=9.84953e-15
cg277_8 xdut.vrr_ok 0 c=5.07723e-14
c277_6 xdut.vrr_ok xdut.xana.xsup.net662 c=1.00489e-15
c277_4 xdut.vrr_ok xdut.reg_vdd_dis c=1.2937e-15
c277_3 xdut.vrr_ok xdut.gnd_p c=6.22961e-15
c277_1 xdut.vrr_ok xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.44305e-14
cg276_18 xdut.atst_sup<4> 0 c=3.21839e-14
c276_11 xdut.atst_sup<4> xdut.trim_i5u<0> c=8.18906e-14
c276_10 xdut.atst_sup<4> xdut.trim_i5u<1> c=4.33469e-15
c276_6 xdut.atst_sup<4> xdut.atst_sup<3> c=8.09925e-14
c276_5 xdut.atst_sup<4> xdut.atst_sup<2> c=4.39498e-15
c276_3 xdut.atst_sup<4> xdut.gnd_p c=4.6506e-15
c276_1 xdut.atst_sup<4> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=2.50679e-15
cg275_17 xdut.trim_i5u<0> 0 c=3.26286e-14
c275_10 xdut.trim_i5u<0> xdut.trim_i5u<1> c=8.23903e-14
c275_9 xdut.trim_i5u<0> xdut.trim_i5u<2> c=4.30176e-15
c275_6 xdut.trim_i5u<0> xdut.atst_sup<3> c=4.28445e-15
c275_3 xdut.trim_i5u<0> xdut.gnd_p c=5.16075e-15
c275_1 xdut.trim_i5u<0> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=3.21209e-15
cg273_16 xdut.trim_i5u<1> 0 c=3.26126e-14
c273_9 xdut.trim_i5u<1> xdut.trim_i5u<2> c=8.30671e-14
c273_8 xdut.trim_i5u<1> xdut.trim_i5u<3> c=4.13521e-15
c273_3 xdut.trim_i5u<1> xdut.gnd_p c=5.48252e-15
c273_1 xdut.trim_i5u<1> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=4.4976e-15
cg272_15 xdut.trim_i5u<2> 0 c=3.16206e-14
c272_8 xdut.trim_i5u<2> xdut.trim_i5u<3> c=8.40978e-14
c272_7 xdut.trim_i5u<2> xdut.vcc_ok c=4.4407e-15
c272_3 xdut.trim_i5u<2> xdut.gnd_p c=5.25006e-15
c272_1 xdut.trim_i5u<2> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=5.95756e-15
cg271_14 xdut.trim_i5u<3> 0 c=3.00913e-14
c271_7 xdut.trim_i5u<3> xdut.vcc_ok c=8.50705e-14
c271_3 xdut.trim_i5u<3> xdut.gnd_p c=5.64925e-15
c271_1 xdut.trim_i5u<3> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=8.54372e-15
cg270_9 xdut.vcc_ok 0 c=3.10354e-14
c270_3 xdut.vcc_ok xdut.gnd_p c=6.10011e-15
c270_1 xdut.vcc_ok xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=9.18228e-15
cg269_12 xdut.atst_sup<3> 0 c=3.25263e-14
c269_5 xdut.atst_sup<3> xdut.atst_sup<2> c=8.00113e-14
c269_4 xdut.atst_sup<3> xdut.atst_sup<1> c=4.39222e-15
c269_3 xdut.atst_sup<3> xdut.gnd_p c=4.27698e-15
c269_1 xdut.atst_sup<3> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=2.17835e-15
cg268_11 xdut.atst_sup<2> 0 c=3.31851e-14
c268_4 xdut.atst_sup<2> xdut.atst_sup<1> c=7.90277e-14
c268_3 xdut.atst_sup<2> xdut.gnd_p c=3.95711e-15
c268_1 xdut.atst_sup<2> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.28756e-15
cg267_10 xdut.atst_sup<1> 0 c=3.2841e-14
c267_3 xdut.atst_sup<1> xdut.gnd_p c=3.62218e-15
c267_1 xdut.atst_sup<1> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.29685e-15
cg266_20 xdut.reg_vdd_dis 0 c=5.26841e-14
c266_14 xdut.reg_vdd_dis xdut.xana.xsup.xvddreg.xvddreg.gate c=3.03255e-15
c266_3 xdut.reg_vdd_dis xdut.gnd_p c=9.49814e-15
c266_2 xdut.reg_vdd_dis xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=2.53467e-15
c266_1 xdut.reg_vdd_dis xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=2.20297e-14
cg260_385 xdut.aout_int 0 c=1.39419e-13
c260_339 xdut.aout_int xdut.xosc.xpll_top_0.xpll_core_0.up c=3.20334e-15
c260_337 xdut.aout_int xdut.xosc.xpll_top_0.xpll_core_0.pd_n c=2.00895e-15
c260_323 xdut.aout_int xdut.xosc.xpll_top_0.xpll_core_0.vtune c=4.12149e-15
c260_312 xdut.aout_int xdut.xosc.xosc_20m_0.xatst_single_0.atst_pll_5v c=1.60184e-15
c260_307 xdut.aout_int xdut.xana.xtmon.xsw1.net28 c=2.32263e-15
c260_292 xdut.aout_int xdut.xana.xsup.xvrrmon.vrr_int c=7.79631e-15
c260_290 xdut.aout_int xdut.xana.xsup.xmux.xsw1.net28 c=2.394e-15
c260_289 xdut.aout_int xdut.xana.xsup.xmux.xsw2.net28 c=2.42165e-15
c260_279 xdut.aout_int xdut.xana.xsup.xmux.xsw3.net28 c=2.42365e-15
c260_278 xdut.aout_int xdut.xana.xsup.xmux.xsw4.net28 c=2.42955e-15
c260_267 xdut.aout_int xdut.xana.xsup.xvrrmon.net42 c=2.43267e-15
c260_261 xdut.aout_int xdut.xana.xotpmux.xsw3.net28 c=2.42216e-15
c260_250 xdut.aout_int xdut.xana.xotpmux.xsw0.net28 c=2.42405e-15
c260_248 xdut.aout_int xdut.xana.xotpmux.xsw1.net28 c=2.44232e-15
c260_244 xdut.aout_int xdut.xana.xotpmux.xsw2.net28 c=2.44788e-15
c260_233 xdut.aout_int xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.vbn5v_div c=1.2423e-15
c260_199 xdut.aout_int xdut.xana.xdsi_ch1<1>.xtx.vdsi_ov_5v c=1.48458e-15
c260_165 xdut.aout_int xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.net1521 c=1.47673e-15
c260_148 xdut.aout_int xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.vbn5v_div c=1.24173e-15
c260_143 xdut.aout_int xdut.xana.xdsi_ch1<0>.xtx.atst_tx_5v<4> c=5.25433e-15
c260_131 xdut.aout_int xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vbn_5v c=2.84156e-15
c260_105 xdut.aout_int xdut.xana.xdsi_ch1<0>.xtx.on_tx_5v c=1.34923e-15
c260_104 xdut.aout_int xdut.xana.xdsi_ch1<0>.xtx.vdsi_ov_5v c=1.48121e-15
c260_70 xdut.aout_int xdut.xana.xdsi_ch1<0>.xtx.atst_tx_5v<5> c=5.61055e-15
c260_57 xdut.aout_int xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.net1521 c=1.40419e-15
c260_16 xdut.aout_int xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd c=3.13363e-15
c260_13 xdut.aout_int xdut.ot_warn c=1.2378e-14
c260_11 xdut.aout_int xdut.ot_adj<0> c=1.30887e-15
c260_7 xdut.aout_int xdut.gnd_dsi c=1.73071e-13
c260_4 xdut.aout_int xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd c=2.4642e-15
c260_3 xdut.aout_int xdut.gnd_p c=9.18185e-13
c260_2 xdut.aout_int xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=8.33412e-14
c260_1 xdut.aout_int xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=2.63915e-14
cg235_16 xdut.xana.xotpmux.dm11c 0 c=1.92396e-14
c235_9 xdut.xana.xotpmux.dm11c xdut.xana.xotpmux.vbn c=2.1055e-15
c235_6 xdut.xana.xotpmux.dm11c xdut.xana.xotpmux.dm1 c=1.03113e-15
c235_5 xdut.xana.xotpmux.dm11c xdut.xana.xotpmux.atst_otp_5v<4> c=2.79844e-15
c235_2 xdut.xana.xotpmux.dm11c xdut.gnd_p c=1.03745e-14
c235_1 xdut.xana.xotpmux.dm11c xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=3.01775e-15
cg231_30 xdut.xana.xldo.vlim 0 c=3.00343e-14
c231_29 xdut.xana.xldo.vlim xdut.xana.xldo.s_cas2 c=4.28293e-15
c231_27 xdut.xana.xldo.vlim xdut.xana.xldo.net636 c=9.84027e-15
c231_26 xdut.xana.xldo.vlim xdut.xana.xldo.net667 c=4.01693e-15
c231_17 xdut.xana.xldo.vlim xdut.xana.xldo.dm2 c=1.64946e-15
c231_4 xdut.xana.xldo.vlim xdut.gnd_dsi c=6.90361e-15
c231_3 xdut.xana.xldo.vlim xdut.cldo_p c=1.46495e-15
c231_2 xdut.xana.xldo.vlim xdut.gnd_p c=8.05387e-14
c231_1 xdut.xana.xldo.vlim xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.20718e-15
cg228_246 xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd 0 c=6.5502e-14
c228_159 xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd xdut.xana.ln_dsi_ch1<1>.rx.iq_cmp.n_235 c=4.469e-15
c228_158 xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.n2 c=3.57666e-15
c228_157 xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.n1 c=3.77902e-15
c228_154 xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.n5 c=2.30946e-15
c228_153 xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.n6 c=2.19459e-15
c228_137 xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd xdut.xana.xdsi_ch1<1>.xrx.xflt3.net6 c=2.00291e-15
c228_129 xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd xdut.xana.xdsi_ch1<1>.xrx.xflt2.net6 c=2.00631e-15
c228_121 xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd xdut.xana.xdsi_ch1<1>.xrx.xflt1.net6 c=2.00602e-15
c228_49 xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd xdut.xana.xdsi_ch1<1>.xrx.net899 c=5.81994e-15
c228_38 xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd xdut.xana.xdsi_ch1<1>.xrx.inn_d2cmp c=1.19419e-13
c228_26 xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd xdut.xana.xdsi_ch1<1>.xrx.inp_d2cmp c=1.12965e-13
c228_15 xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd xdut.xana.xdsi_ch1<1>.xrx.flt_fast_5v c=6.32786e-15
c228_14 xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd xdut.xana.xdsi_ch1<1>.xrx.xls8.net107 c=1.21522e-14
c228_9 xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd xdut.xana.xdsi_ch1<1>.xrx.xdat2_cmp.n3 c=6.73752e-15
c228_8 xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd xdut.xana.xdsi_ch1<1>.xrx.xdat2_cmp.n4 c=6.13115e-15
c228_4 xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd xdut.gnd_dsi c=1.09461e-12
c228_2 xdut.xana.xdsi_ch1<1>.xrx.vhs_gnd xdut.gnd_p c=3.56268e-14
cg227_15 xdut.xana.xdsi_ch1<0>.xrx.xrec_th.offs_sw_d 0 c=1.88183e-15
c227_3 xdut.xana.xdsi_ch1<0>.xrx.xrec_th.offs_sw_d xdut.gnd_dsi c=1.6536e-14
cg223_15 xdut.xana.xsup.xvddreg.xvddreg.v5raw 0 c=1.58727e-13
c223_7 xdut.xana.xsup.xvddreg.xvddreg.v5raw xdut.xana.xsup.xvccreg.xreg.nbl1 c=1.94373e-15
c223_4 xdut.xana.xsup.xvddreg.xvddreg.v5raw xdut.vsup_p c=1.12809e-12
c223_3 xdut.xana.xsup.xvddreg.xvddreg.v5raw xdut.gnd_p c=2.27431e-13
cg200_12 xdut.en_atb 0 c=2.5674e-14
c200_3 xdut.en_atb xdut.gnd_p c=7.19581e-15
c200_2 xdut.en_atb xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.73333e-14
c200_1 xdut.en_atb xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=8.20722e-15
cg199_32 xdut.atst_ts<1> 0 c=4.41433e-14
c199_8 xdut.atst_ts<1> xdut.ot_adj<0> c=9.86215e-15
c199_7 xdut.atst_ts<1> xdut.atst_ts<0> c=1.89529e-13
c199_6 xdut.atst_ts<1> xdut.ot_adj<1> c=1.85313e-13
c199_5 xdut.atst_ts<1> xdut.gnd_dsi c=1.54041e-15
c199_3 xdut.atst_ts<1> xdut.gnd_p c=2.17516e-15
c199_2 xdut.atst_ts<1> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=6.27521e-15
c199_1 xdut.atst_ts<1> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=4.97504e-15
cg198_18 xdut.ot_warn 0 c=7.41056e-14
c198_12 xdut.ot_warn xdut.xana.xtmon.net687 c=8.8268e-15
c198_10 xdut.ot_warn xdut.xana.xtmon.net628 c=1.00263e-15
c198_9 xdut.ot_warn xdut.ot_error c=1.72467e-13
c198_8 xdut.ot_warn xdut.ot_adj<0> c=8.26196e-15
c198_3 xdut.ot_warn xdut.gnd_p c=4.00514e-15
c198_2 xdut.ot_warn xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=8.52476e-15
c198_1 xdut.ot_warn xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=5.35517e-15
cg197_17 xdut.ot_error 0 c=4.35369e-14
c197_16 xdut.ot_error xdut.xana.xtmon.net697 c=1.02002e-15
c197_14 xdut.ot_error xdut.xana.xtmon.v_tsens_i c=6.07099e-15
c197_8 xdut.ot_error xdut.ot_adj<0> c=1.67958e-13
c197_7 xdut.ot_error xdut.atst_ts<0> c=2.24491e-15
c197_6 xdut.ot_error xdut.ot_adj<1> c=8.87286e-15
c197_5 xdut.ot_error xdut.gnd_dsi c=2.4543e-15
c197_3 xdut.ot_error xdut.gnd_p c=3.4134e-15
c197_2 xdut.ot_error xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=6.00923e-15
c197_1 xdut.ot_error xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=4.29582e-15
cg196_26 xdut.ot_adj<0> 0 c=4.85253e-14
c196_14 xdut.ot_adj<0> xdut.xana.xtmon.net699 c=2.55207e-15
c196_6 xdut.ot_adj<0> xdut.ot_adj<1> c=1.82964e-13
c196_5 xdut.ot_adj<0> xdut.gnd_dsi c=1.66476e-15
c196_3 xdut.ot_adj<0> xdut.gnd_p c=2.27085e-15
c196_2 xdut.ot_adj<0> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=7.23885e-15
c196_1 xdut.ot_adj<0> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=3.63594e-15
cg195_23 xdut.atst_ts<0> 0 c=7.19594e-14
c195_7 xdut.atst_ts<0> xdut.ot_adj<1> c=1.02993e-14
c195_6 xdut.atst_ts<0> xdut.gnd_dsi c=1.54817e-15
c195_3 xdut.atst_ts<0> xdut.gnd_p c=3.53066e-15
c195_2 xdut.atst_ts<0> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=9.40519e-15
c195_1 xdut.atst_ts<0> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.1496e-14
cg194_22 xdut.ot_adj<1> 0 c=4.98085e-14
c194_5 xdut.ot_adj<1> xdut.gnd_dsi c=1.52683e-15
c194_3 xdut.ot_adj<1> xdut.gnd_p c=2.2251e-15
c194_2 xdut.ot_adj<1> xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=5.97993e-15
c194_1 xdut.ot_adj<1> xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=4.21948e-15
cg165_1804 xdut.gnd_dsi 0 c=7.94493e-12
c165_1803 xdut.gnd_dsi xdut.xana.xtmon.xtsens.net21 c=4.25487e-15
c165_1802 xdut.gnd_dsi xdut.xana.xtmon.v_tsens_i c=1.27667e-15
c165_1794 xdut.gnd_dsi xdut.xana.xtmon.v_tsens c=1.49193e-15
c165_1788 xdut.gnd_dsi xdut.xana.xldo.s_cas2 c=2.93771e-14
c165_1787 xdut.gnd_dsi xdut.xana.xldo.s_cas1 c=2.08641e-14
c165_1786 xdut.gnd_dsi xdut.xana.xldo.net636 c=2.22387e-14
c165_1785 xdut.gnd_dsi xdut.xana.xldo.net667 c=1.1526e-14
c165_1784 xdut.gnd_dsi xdut.xana.xldo.net634 c=1.27836e-15
c165_1782 xdut.gnd_dsi xdut.xana.xldo.vd_msen c=1.96876e-14
c165_1781 xdut.gnd_dsi xdut.xana.xldo.vd_m0 c=8.68493e-15
c165_1780 xdut.gnd_dsi xdut.xana.xldo.ota_out c=1.88003e-14
c165_1766 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_imirror_0.kibg c=5.06144e-15
c165_1765 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_imirror_0.net1728 c=1.21151e-15
c165_1764 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_imirror_0.net1726 c=7.78209e-15
c165_1763 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_imirror_0.vdmpo<1> c=9.28481e-15
c165_1762 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_imirror_0.net1727 c=7.62498e-15
c165_1761 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_imirror_0.net1730 c=6.96485e-15
c165_1760 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_d2i_0.xtx_d2i_idac_0.net1196 c=3.54049e-15
c165_1759 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_d2i_0.xtx_d2i_idac_0.net1195 c=3.56917e-15
c165_1647 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.vbn5v_div c=1.03942e-14
c165_1644 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vpc1 c=2.93531e-15
c165_1642 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vpco c=1.63378e-14
c165_1641 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.tx.tx_amp_fb_0.tx_amp_rdiv_sup.n_9 c=2.72732e-15
c165_1640 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.tx.tx_amp_fb_0.tx_amp_rdiv_sup.n_8 c=5.27098e-15
c165_1639 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.tx.tx_amp_fb_0.tx_amp_rdiv_sup.n_19 c=2.67584e-15
c165_1638 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.tx.tx_amp_fb_0.tx_amp_rdiv_sup.n_18 c=2.69341e-15
c165_1637 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.tx.tx_amp_fb_0.tx_amp_rdiv_sup.n_17 c=2.61036e-15
c165_1636 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.tx.tx_amp_fb_0.tx_amp_rdiv_sup.n_16 c=2.556e-15
c165_1635 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.tx.tx_amp_fb_0.tx_amp_rdiv_sup.n_15 c=2.75748e-15
c165_1634 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.tx.tx_amp_fb_0.tx_amp_rdiv_sup.n_14 c=2.59172e-15
c165_1633 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.tx.tx_amp_fb_0.tx_amp_rdiv_sup.n_13 c=2.67964e-15
c165_1632 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.tx.tx_amp_fb_0.tx_amp_rdiv_sup.n_12 c=2.75606e-15
c165_1631 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.tx.tx_amp_fb_0.tx_amp_rdiv_sup.n_11 c=2.68117e-15
c165_1630 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.tx.tx_amp_fb_0.tx_amp_rdiv_sup.n_10 c=2.75142e-15
c165_1629 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.net154 c=5.62409e-15
c165_1628 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.tx.tx_amp_fb_0.tx_amp_rdiv_out.n_20 c=2.75842e-15
c165_1627 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.tx.tx_amp_fb_0.tx_amp_rdiv_out.n_19 c=2.67566e-15
c165_1626 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.tx.tx_amp_fb_0.tx_amp_rdiv_out.n_18 c=2.77019e-15
c165_1625 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.tx.tx_amp_fb_0.tx_amp_rdiv_out.n_17 c=2.67954e-15
c165_1624 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.tx.tx_amp_fb_0.tx_amp_rdiv_out.n_16 c=2.67987e-15
c165_1623 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.tx.tx_amp_fb_0.tx_amp_rdiv_out.n_15 c=2.76829e-15
c165_1622 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.tx.tx_amp_fb_0.tx_amp_rdiv_out.n_14 c=2.43681e-15
c165_1621 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.tx.tx_amp_fb_0.tx_amp_rdiv_out.n_13 c=2.72793e-15
c165_1620 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.tx.tx_amp_fb_0.tx_amp_rdiv_out.n_12 c=2.61506e-15
c165_1619 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.tx.tx_amp_fb_0.tx_amp_rdiv_out.n_11 c=2.52301e-15
c165_1618 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.tx.tx_amp_fb_0.tx_amp_rdiv_out.n_10 c=2.76829e-15
c165_1617 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xsw_trx_0.vrr c=1.48368e-15
c165_1616 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xsw_trx_0.vgsw c=2.18022e-15
c165_1614 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.vh05 c=1.10329e-14
c165_1613 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vbp_5v c=1.0319e-14
c165_1610 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.vh05ov c=9.91962e-15
c165_1608 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.vdiv c=1.37974e-14
c165_1582 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.inn_5v c=2.12904e-14
c165_1575 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.tx_data_5v<4> c=7.85094e-15
c165_1572 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.tx_data_5v<3> c=6.63119e-15
c165_1567 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.tx_data_5v<2> c=6.64902e-15
c165_1566 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.tx_data_5v<1> c=7.23294e-15
c165_1549 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.vdsi_ov_5v c=1.56217e-14
c165_1548 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vnglim c=7.94228e-15
c165_1545 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vdiffo c=1.31094e-14
c165_1543 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vgnxl c=1.95625e-14
c165_1531 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.tx_data_5v<0> c=9.49239e-15
c165_1526 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.atst_tx_5v<6> c=1.1907e-14
c165_1511 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.i5u_int_5v<0> c=1.26504e-14
c165_1510 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.idac_5v<1> c=1.77122e-14
c165_1509 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.i5u_int_5v<1> c=5.94432e-15
c165_1506 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_imirror_0.kibc c=4.56931e-15
c165_1505 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_imirror_0.vbn c=1.56862e-13
c165_1504 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_imirror_0.vbint2<1> c=1.09104e-14
c165_1503 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_imirror_0.vbint1<2> c=1.08057e-14
c165_1502 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_imirror_0.vbint1<1> c=1.09385e-14
c165_1501 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_imirror_0.vbint2<0> c=1.16207e-14
c165_1500 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.net934 c=1.93715e-15
c165_1499 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.net933 c=9.86823e-15
c165_1498 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.idac_5v<2> c=2.79066e-14
c165_1497 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_imirror_0.vbnc c=1.01747e-14
c165_1495 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_imirror_0.net1671 c=7.56664e-15
c165_1494 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_imirror_0.vdsi_ctrl_l_5v<2> c=6.51993e-15
c165_1493 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_imirror_0.vdsi_ctrl_l_5v<1> c=1.92346e-15
c165_1492 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_imirror_0.vdsi_ctrl_l_5v<0> c=1.94564e-15
c165_1491 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_imirror_0.net1355 c=1.03759e-14
c165_1487 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_lvl_in_0.xi_on_tx.pull_up c=1.05945e-15
c165_1477 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls7.pull_up c=1.06503e-15
c165_1451 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls4<0>.pull_up c=1.06335e-15
c165_1434 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.ibg10u_5v<1> c=1.57236e-14
c165_1430 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls1.pull_up c=1.11381e-15
c165_1425 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xi44.net7 c=1.58913e-15
c165_1424 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.net935 c=1.53903e-14
c165_1423 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.tx_5v c=5.92823e-15
c165_1406 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_96 c=1.85772e-15
c165_1405 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_95 c=1.82501e-15
c165_1404 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_94 c=1.85979e-15
c165_1403 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_93 c=1.83231e-15
c165_1402 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_92 c=1.85576e-15
c165_1401 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_91 c=1.85967e-15
c165_1400 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_90 c=1.85204e-15
c165_1399 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrshunt.net1142 c=2.83113e-15
c165_1398 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_89 c=1.85037e-15
c165_1397 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_88 c=1.85806e-15
c165_1396 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_87 c=1.82595e-15
c165_1395 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_86 c=1.85203e-15
c165_1394 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_85 c=1.83325e-15
c165_1393 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_84 c=1.8561e-15
c165_1392 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_83 c=1.85191e-15
c165_1391 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_82 c=1.84894e-15
c165_1390 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_81 c=1.8506e-15
c165_1389 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_77 c=1.85806e-15
c165_1388 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_76 c=1.82505e-15
c165_1387 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_75 c=1.852e-15
c165_1386 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_74 c=1.83234e-15
c165_1385 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_73 c=1.8561e-15
c165_1384 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_72 c=1.85188e-15
c165_1383 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrshunt.net1147 c=1.84777e-15
c165_1382 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrshunt.net1151 c=1.84939e-15
c165_1381 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_65 c=1.85822e-15
c165_1380 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_64 c=1.85679e-15
c165_1379 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrshunt.net1153 c=1.84803e-15
c165_1378 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrshunt.net1154 c=1.84965e-15
c165_1377 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrshunt.net1145 c=3.34795e-15
c165_1376 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrshunt.net1149 c=3.33972e-15
c165_1375 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_24 c=1.83626e-15
c165_1374 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_22 c=1.83441e-15
c165_1373 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrshunt.net1139 c=5.68265e-15
c165_1372 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrshunt.net1140 c=2.36446e-15
c165_1371 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_103 c=1.82143e-15
c165_1370 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_101 c=1.82877e-15
c165_1369 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.net46 c=7.01169e-15
c165_1368 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.vbn c=1.64726e-14
c165_1367 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.net51 c=6.31809e-15
c165_1366 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.on_os_2 c=3.12386e-15
c165_1364 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.on_os_1 c=2.27682e-15
c165_1362 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.on_os_0 c=2.92558e-15
c165_1361 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.on_osb_0 c=1.0123e-15
c165_1360 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.ios_sum c=2.61968e-15
c165_1359 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.vbnc c=1.2752e-14
c165_1345 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.net42 c=1.68192e-15
c165_1344 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.net46 c=7.02994e-15
c165_1343 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.vbn c=1.6489e-14
c165_1342 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.net51 c=6.02854e-15
c165_1341 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.on_os_2 c=3.12976e-15
c165_1340 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.on_osb_2 c=1.00358e-15
c165_1339 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.on_os_1 c=2.26954e-15
c165_1337 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.on_os_0 c=2.873e-15
c165_1336 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.on_osb_0 c=1.01166e-15
c165_1335 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.ios_sum c=2.58482e-15
c165_1334 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.vbnc c=1.27909e-14
c165_1320 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.net42 c=1.71331e-15
c165_1319 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.nd4 c=1.57155e-14
c165_1318 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.ns4 c=6.12005e-15
c165_1316 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.nsdum c=7.95545e-15
c165_1315 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.on_1 c=1.84397e-15
c165_1314 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.onb_1 c=1.07963e-15
c165_1313 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.on_2 c=1.87739e-15
c165_1312 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.onb_2 c=1.07558e-15
c165_1311 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.on_3 c=2.17531e-15
c165_1310 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.onb_3 c=1.06746e-15
c165_1309 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.on_4 c=3.70542e-15
c165_1308 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.onb_4 c=1.11758e-15
c165_1307 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.idac2atb_5v_b c=7.27739e-15
c165_1306 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.idac2atb_5v_i c=2.23749e-15
c165_1305 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.on_0 c=1.72713e-15
c165_1304 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.net1521 c=1.45114e-15
c165_1303 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.nd0 c=2.99737e-15
c165_1301 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.onb_0 c=1.03734e-15
c165_1300 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.nd1 c=1.9618e-15
c165_1298 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.nd2 c=1.40898e-15
c165_1297 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.ns2 c=1.30527e-15
c165_1296 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.nd3 c=1.37385e-15
c165_1295 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.ns3 c=2.62298e-15
c165_1291 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.pbias2_cs c=7.01292e-15
c165_1288 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.on_os_3 c=3.04682e-15
c165_1287 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.on_osb_3 c=3.43221e-15
c165_1286 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.on_os_3 c=2.98191e-15
c165_1285 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.on_osb_3 c=3.05675e-15
c165_1281 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.pbias1_cs c=7.62509e-15
c165_1277 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.ls8.n_60 c=1.66795e-15
c165_1276 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.ls8.n_59 c=4.12778e-15
c165_1275 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls8.net106 c=4.03301e-15
c165_1274 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls8.net104 c=7.64095e-15
c165_1264 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.n7 c=3.04605e-15
c165_1263 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.xi106.p0 c=1.75741e-15
c165_1261 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.on_v5v_ana_b c=1.00822e-15
c165_1259 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.n2 c=1.24389e-15
c165_1258 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.n1 c=1.09272e-15
c165_1254 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.n5 c=8.04584e-15
c165_1253 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.n6 c=7.49141e-15
c165_1252 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xhs_sup.nd_mnb2 c=3.54356e-15
c165_1251 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xhs_sup.vl5 c=2.18786e-15
c165_1249 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xhs_sup.net176 c=1.95853e-15
c165_1248 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xhs_sup.ndio_lv c=1.95447e-14
c165_1247 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xhs_sup.mn_hv_lim_d c=9.8592e-15
c165_1246 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xhs_sup.on_v5v_ana_i c=2.00832e-15
c165_1245 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xhs_sup.on_v5v_ana_b c=1.97597e-15
c165_1244 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xhs_sup.pdio_lv c=5.49196e-15
c165_1241 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.hs_sup.n_343 c=1.10199e-15
c165_1229 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.hs_sup.n_331 c=2.79303e-15
c165_1227 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.hs_sup.n_329 c=1.23486e-15
c165_1225 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.hs_sup.n_327 c=1.02338e-15
c165_1183 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.hs_sup.n_285 c=1.65213e-15
c165_1178 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xhs_sup.nd_mncas c=1.30545e-15
c165_1172 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xhs_sup.vl4 c=1.26432e-15
c165_1171 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xhs_sup.vr1 c=1.03468e-15
c165_1156 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xdat2_cmp.data_comp_in c=1.62359e-15
c165_1153 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xdat2_cmp.cmp_out_dig c=1.25034e-15
c165_1152 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xdat2_cmp.xi106.p0 c=1.91786e-15
c165_1151 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xdat2_cmp.xi232.x_u4-net13 c=1.49739e-15
c165_1150 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xdat2_cmp.cmp_out_ana c=5.33483e-15
c165_1149 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xdat2_cmp.n7 c=3.37295e-15
c165_1148 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xdat2_cmp.on_v5v_ana_b c=1.16143e-15
c165_1147 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<1>.rx.dat2_cmp.n_367 c=1.13115e-15
c165_1135 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xdat2_cmp.n5 c=9.63766e-15
c165_1134 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xdat2_cmp.n6 c=9.63749e-15
c165_1132 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xdat2_cmp.net462 c=1.49357e-15
c165_1119 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xdat1_cmp.data_comp_in c=1.62039e-15
c165_1116 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xdat1_cmp.cmp_out_dig c=1.24813e-15
c165_1115 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xdat1_cmp.xi106.p0 c=1.90977e-15
c165_1114 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xdat1_cmp.xi232.x_u4-net13 c=1.49349e-15
c165_1113 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xdat1_cmp.cmp_out_ana c=5.30559e-15
c165_1112 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xdat1_cmp.n7 c=3.40317e-15
c165_1111 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xdat1_cmp.on_v5v_ana_b c=1.16604e-15
c165_1108 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xdat1_cmp.n5 c=9.69453e-15
c165_1107 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xdat1_cmp.n6 c=9.69824e-15
c165_1103 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls9<4>.xd2a_hvpart_inst.net038 c=1.37098e-15
c165_1101 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls9<2>.xd2a_hvpart_inst.net038 c=1.37574e-15
c165_1099 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls9<1>.xd2a_hvpart_inst.net038 c=1.38004e-15
c165_1097 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.rxd2_5v c=1.76415e-14
c165_1095 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls4<3>.ls_a c=1.04205e-15
c165_1093 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls4<2>.ls_a c=1.04052e-15
c165_1091 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls4<1>.ls_a c=1.03689e-15
c165_1089 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls4<0>.ls_a c=1.03982e-15
c165_1087 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls5<3>.ls_a c=1.04093e-15
c165_1085 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls5<2>.ls_a c=1.04256e-15
c165_1082 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls5<1>.ls_a c=1.04267e-15
c165_1081 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls5<0>.ls_a c=1.04857e-15
c165_1079 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls7.ls_a c=1.04064e-15
c165_1066 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.net899 c=1.65715e-15
c165_1063 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.nd2_cs c=4.08322e-15
c165_1055 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.on_v5v_ana_b c=8.70782e-15
c165_1054 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.on_v5v_ana_i c=6.11511e-15
c165_1046 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.nbias_os_cas c=2.79961e-14
c165_1045 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.noffset_bias2 c=1.33422e-15
c165_1044 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.nbias_os c=7.54436e-14
c165_1043 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.inn_d2cmp c=8.78179e-15
c165_1042 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.nd7_cs c=5.228e-15
c165_1041 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.nd8_cs c=8.03735e-15
c165_1040 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.nd6_cs c=7.49596e-15
c165_1039 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.nd4_cs c=2.1296e-15
c165_1038 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.nbias_cs c=1.13572e-13
c165_1037 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.nd5_cs c=3.82193e-15
c165_1036 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.nd3_cs c=2.39414e-15
c165_1035 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.bias_idac c=1.1047e-13
c165_1034 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.idac_bias2 c=2.22197e-15
c165_1033 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.idac_bias1 c=3.30048e-15
c165_1032 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.bias_idac_cas c=2.20704e-14
c165_1031 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.inp_d2cmp c=1.18782e-14
c165_1029 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls1.xd2a_hvpart_inst.net038 c=1.45938e-15
c165_1027 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xdat2_cmp.n2 c=3.10928e-15
c165_1026 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls1.pull_up c=1.15249e-15
c165_1025 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.trim_dcmp1_5v<3> c=5.74535e-15
c165_1024 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls4<0>.pull_up c=1.13824e-15
c165_1018 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.trim_dcmp1_5v<2> c=4.83586e-15
c165_1017 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xdat2_cmp.n1 c=3.04577e-15
c165_1016 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls4<3>.xd2a_hvpart_inst.net038 c=1.42132e-15
c165_1014 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls4<1>.pull_up c=1.13862e-15
c165_1011 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls4<2>.xd2a_hvpart_inst.net038 c=1.42202e-15
c165_1010 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls4<1>.xd2a_hvpart_inst.net038 c=1.42184e-15
c165_1008 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.trim_dcmp1_5v<1> c=5.13638e-15
c165_1007 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls4<2>.pull_up c=1.13923e-15
c165_1004 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls4<0>.xd2a_hvpart_inst.net038 c=1.42247e-15
c165_1002 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.trim_dcmp1_5v<0> c=1.15332e-14
c165_1001 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.trim_dcmp2_5v<3> c=4.69239e-15
c165_1000 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls4<3>.pull_up c=1.14055e-15
c165_997 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls6.pull_up c=1.13973e-15
c165_996 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls5<3>.xd2a_hvpart_inst.net038 c=1.42167e-15
c165_994 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.trim_dcmp2_5v<2> c=3.34974e-15
c165_991 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls5<0>.pull_up c=1.13477e-15
c165_988 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls5<2>.xd2a_hvpart_inst.net038 c=1.42235e-15
c165_985 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.trim_dcmp2_5v<1> c=3.08086e-15
c165_984 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls5<1>.pull_up c=1.13869e-15
c165_981 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls5<1>.xd2a_hvpart_inst.net038 c=1.42707e-15
c165_980 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls5<0>.xd2a_hvpart_inst.net038 c=1.4232e-15
c165_978 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.trim_dcmp2_5v<0> c=6.03971e-15
c165_977 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.flt_fast_5v c=1.55337e-14
c165_976 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls5<2>.pull_up c=1.14434e-15
c165_973 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls7.xd2a_hvpart_inst.net038 c=1.46829e-15
c165_964 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls9<0>.xd2a_hvpart_inst.net038 c=1.43484e-15
c165_962 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls9<3>.xd2a_hvpart_inst.net038 c=1.41442e-15
c165_960 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls9<0>.pull_up c=1.11064e-15
c165_959 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls9<3>.pull_up c=1.09726e-15
c165_956 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls9<1>.pull_up c=1.09489e-15
c165_953 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls5<3>.pull_up c=1.10561e-15
c165_952 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls9<4>.pull_up c=1.10473e-15
c165_949 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls9<2>.pull_up c=1.09173e-15
c165_948 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls8.net107 c=6.60933e-15
c165_945 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls6.xd2a_hvpart_inst.net038 c=1.36726e-15
c165_943 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.dat2_sw_d c=2.13813e-14
c165_942 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.dat1_sw_d c=1.62433e-14
c165_941 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.idat_os_summe c=6.19737e-15
c165_940 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.idat_os_summe c=6.2162e-15
c165_939 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xdat2_cmp.n3 c=1.18574e-14
c165_938 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xdat2_cmp.n4 c=5.47397e-15
c165_937 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xhs_sup.mphv_reg_d c=1.02409e-14
c165_936 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xhs_sup.vreg_ref c=1.12783e-14
c165_922 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.kibg c=5.06741e-15
c165_921 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.net1728 c=1.21493e-15
c165_920 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.net1726 c=7.77791e-15
c165_919 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.vdmpo<1> c=9.29025e-15
c165_918 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.net1727 c=7.6288e-15
c165_917 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.net1730 c=6.78421e-15
c165_916 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_d2i_0.xtx_d2i_idac_0.net1196 c=3.55847e-15
c165_915 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_d2i_0.xtx_d2i_idac_0.net1195 c=3.56808e-15
c165_800 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.vbn5v_div c=1.0394e-14
c165_798 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2652 c=1.92248e-14
c165_797 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2668 c=1.60003e-14
c165_796 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2662 c=2.03867e-14
c165_793 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vpc1 c=2.88487e-15
c165_792 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vpgo c=5.12746e-15
c165_791 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2529 c=2.18483e-15
c165_790 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vpco c=1.68807e-14
c165_789 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.tx.tx_amp_fb_0.tx_amp_rdiv_sup.n_9 c=2.73732e-15
c165_788 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.tx.tx_amp_fb_0.tx_amp_rdiv_sup.n_8 c=5.27544e-15
c165_787 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.tx.tx_amp_fb_0.tx_amp_rdiv_sup.n_19 c=2.66104e-15
c165_786 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.tx.tx_amp_fb_0.tx_amp_rdiv_sup.n_18 c=2.69197e-15
c165_785 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.tx.tx_amp_fb_0.tx_amp_rdiv_sup.n_17 c=2.60446e-15
c165_784 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.tx.tx_amp_fb_0.tx_amp_rdiv_sup.n_16 c=2.54189e-15
c165_783 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.tx.tx_amp_fb_0.tx_amp_rdiv_sup.n_15 c=2.75475e-15
c165_782 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.tx.tx_amp_fb_0.tx_amp_rdiv_sup.n_14 c=2.5813e-15
c165_781 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.tx.tx_amp_fb_0.tx_amp_rdiv_sup.n_13 c=2.66816e-15
c165_780 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.tx.tx_amp_fb_0.tx_amp_rdiv_sup.n_12 c=2.74975e-15
c165_779 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.tx.tx_amp_fb_0.tx_amp_rdiv_sup.n_11 c=2.67499e-15
c165_778 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.tx.tx_amp_fb_0.tx_amp_rdiv_sup.n_10 c=2.74398e-15
c165_777 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.net154 c=5.62788e-15
c165_776 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.tx.tx_amp_fb_0.tx_amp_rdiv_out.n_20 c=2.748e-15
c165_775 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.tx.tx_amp_fb_0.tx_amp_rdiv_out.n_19 c=2.66857e-15
c165_774 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.tx.tx_amp_fb_0.tx_amp_rdiv_out.n_18 c=2.7574e-15
c165_773 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.tx.tx_amp_fb_0.tx_amp_rdiv_out.n_17 c=2.67482e-15
c165_772 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.tx.tx_amp_fb_0.tx_amp_rdiv_out.n_16 c=2.67478e-15
c165_771 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.tx.tx_amp_fb_0.tx_amp_rdiv_out.n_15 c=2.76092e-15
c165_770 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.tx.tx_amp_fb_0.tx_amp_rdiv_out.n_14 c=2.42042e-15
c165_769 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.tx.tx_amp_fb_0.tx_amp_rdiv_out.n_13 c=2.71863e-15
c165_768 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.tx.tx_amp_fb_0.tx_amp_rdiv_out.n_12 c=2.59578e-15
c165_767 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.tx.tx_amp_fb_0.tx_amp_rdiv_out.n_11 c=2.51934e-15
c165_766 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.tx.tx_amp_fb_0.tx_amp_rdiv_out.n_10 c=2.75234e-15
c165_765 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xsw_trx_0.vrr c=1.48928e-15
c165_764 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xsw_trx_0.vgsw c=2.19046e-15
c165_762 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.vh05 c=1.10369e-14
c165_761 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vbp_5v c=1.0359e-14
c165_758 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.vh05ov c=9.8435e-15
c165_756 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.vdiv c=1.38158e-14
c165_755 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.atst_tx_5v<0> c=3.92457e-15
c165_754 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.atst_tx_5v<4> c=2.52491e-15
c165_753 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.atst_tx_5v<3> c=3.18369e-15
c165_752 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.atst_tx_5v<2> c=6.48471e-15
c165_733 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vbn_5v c=5.26322e-14
c165_725 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.inn_5v c=2.13001e-14
c165_721 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.vdsi_ok_5v c=7.74699e-15
c165_717 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.tx_data_5v<4> c=7.83073e-15
c165_714 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.tx_data_5v<3> c=6.62229e-15
c165_709 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.tx_data_5v<2> c=6.6171e-15
c165_708 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.tx_data_5v<1> c=7.20892e-15
c165_699 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xi44.xu42-net12 c=3.33667e-14
c165_695 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.on_tx_5v c=1.02971e-14
c165_689 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.vdsi_ov_5v c=1.56897e-14
c165_688 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vnglim c=7.88895e-15
c165_685 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vdiffo c=1.30839e-14
c165_684 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2240 c=1.3818e-14
c165_683 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vgnxl c=1.95537e-14
c165_680 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2248 c=9.80431e-15
c165_679 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2536 c=8.11434e-15
c165_677 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vncin2 c=3.08547e-14
c165_670 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.tx_data_5v<0> c=9.5364e-15
c165_665 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.atst_tx_5v<6> c=1.18775e-14
c165_662 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.tx_cfg_5v<1> c=2.09497e-14
c165_658 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.tx_cfg_5v<0> c=1.65272e-14
c165_652 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.vdsi_ctrl_5v<2> c=4.41678e-15
c165_647 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.vdsi_ctrl_5v<1> c=3.5644e-15
c165_646 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.i5u_int_5v<0> c=1.26172e-14
c165_645 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.idac_5v<1> c=1.76198e-14
c165_644 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.i5u_int_5v<1> c=5.94242e-15
c165_641 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.vdsi_ctrl_5v<0> c=5.51498e-15
c165_640 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.kibc c=4.57126e-15
c165_639 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.vbn c=1.56972e-13
c165_638 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.vbint2<1> c=1.09361e-14
c165_637 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.vbint1<2> c=1.07919e-14
c165_636 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.vbint1<1> c=1.0932e-14
c165_635 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.vbint2<0> c=1.16283e-14
c165_634 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.net934 c=1.93725e-15
c165_633 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.net933 c=9.87865e-15
c165_632 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.idac_5v<2> c=2.79852e-14
c165_631 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.vbnc c=1.02139e-14
c165_629 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.rx_txn_5v c=1.76358e-14
c165_628 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.net1671 c=7.64192e-15
c165_627 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.vdsi_ctrl_l_5v<2> c=6.52987e-15
c165_626 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.vdsi_ctrl_l_5v<1> c=1.92116e-15
c165_625 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.vdsi_ctrl_l_5v<0> c=1.9396e-15
c165_624 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.net1355 c=1.03813e-14
c165_617 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_lvl_in_0.xi_tx_cfg<0>.pull_up c=1.06046e-15
c165_613 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_lvl_in_0.xi_tx_cfg<2>.pull_up c=1.06428e-15
c165_607 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls9<2>.pull_up c=1.06206e-15
c165_604 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls9<1>.pull_up c=1.0565e-15
c165_601 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls9<4>.pull_up c=1.05766e-15
c165_598 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls7.pull_up c=1.06364e-15
c165_595 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls9<3>.pull_up c=1.06293e-15
c165_591 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_lvl_in_0.xi_tx_cfg<1>.pull_up c=1.06987e-15
c165_588 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls9<0>.pull_up c=1.06616e-15
c165_584 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls4<2>.pull_up c=1.0622e-15
c165_581 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls5<3>.pull_up c=1.05913e-15
c165_578 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls5<2>.pull_up c=1.058e-15
c165_576 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls5<0>.pull_up c=1.05454e-15
c165_573 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls6.pull_up c=1.06404e-15
c165_572 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.atst_tx_5v<5> c=7.00091e-15
c165_569 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls4<3>.pull_up c=1.06762e-15
c165_567 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls5<1>.pull_up c=1.05611e-15
c165_566 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.ibg10u_5v<1> c=1.56964e-14
c165_562 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls4<1>.pull_up c=1.12122e-15
c165_557 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xi44.net7 c=1.59442e-15
c165_556 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.net935 c=1.53445e-14
c165_555 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.tx_5v c=5.82007e-15
c165_553 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.on_5v_n c=1.60423e-14
c165_538 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.atst_tx_5v<1> c=2.3328e-15
c165_537 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_96 c=1.85772e-15
c165_536 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_95 c=1.83231e-15
c165_535 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_94 c=1.85979e-15
c165_534 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_93 c=1.83231e-15
c165_533 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_92 c=1.85576e-15
c165_532 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_91 c=1.85967e-15
c165_531 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_90 c=1.85336e-15
c165_530 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrshunt.net1142 c=2.83152e-15
c165_529 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_89 c=1.85336e-15
c165_528 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_88 c=1.85806e-15
c165_527 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_87 c=1.83325e-15
c165_526 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_86 c=1.85203e-15
c165_525 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_85 c=1.83325e-15
c165_524 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_84 c=1.8561e-15
c165_523 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_83 c=1.85191e-15
c165_522 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_82 c=1.85193e-15
c165_521 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_81 c=1.85193e-15
c165_520 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_77 c=1.85805e-15
c165_519 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_76 c=1.83234e-15
c165_518 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_75 c=1.852e-15
c165_517 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_74 c=1.83234e-15
c165_516 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_73 c=1.8561e-15
c165_515 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_72 c=1.85188e-15
c165_514 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrshunt.net1147 c=1.85071e-15
c165_513 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrshunt.net1151 c=1.85071e-15
c165_512 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_65 c=1.85822e-15
c165_511 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_64 c=1.85679e-15
c165_510 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrshunt.net1153 c=1.85097e-15
c165_509 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrshunt.net1154 c=1.85097e-15
c165_508 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrshunt.net1145 c=3.34914e-15
c165_507 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrshunt.net1149 c=3.34135e-15
c165_506 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_24 c=1.83626e-15
c165_505 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_22 c=1.83441e-15
c165_504 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrshunt.net1139 c=5.69814e-15
c165_503 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrshunt.net1140 c=2.36455e-15
c165_502 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_103 c=1.82877e-15
c165_501 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_101 c=1.82877e-15
c165_500 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim2.net46 c=7.01208e-15
c165_499 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim2.vbn c=1.64829e-14
c165_498 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim2.net51 c=6.31442e-15
c165_497 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim2.on_os_2 c=3.13521e-15
c165_496 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim2.on_osb_2 c=1.00378e-15
c165_495 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim2.on_os_1 c=2.26012e-15
c165_493 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim2.on_os_0 c=2.86997e-15
c165_492 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim2.on_osb_0 c=1.01201e-15
c165_491 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim2.ios_sum c=2.60796e-15
c165_490 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim2.vbnc c=1.27541e-14
c165_476 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim2.net42 c=1.68098e-15
c165_475 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim1.net46 c=7.03854e-15
c165_474 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim1.vbn c=1.65443e-14
c165_473 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim1.net51 c=6.04061e-15
c165_472 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim1.on_os_2 c=3.12418e-15
c165_471 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim1.on_osb_2 c=1.01494e-15
c165_470 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim1.on_os_1 c=2.23662e-15
c165_468 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim1.on_os_0 c=2.81203e-15
c165_467 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim1.on_osb_0 c=1.00988e-15
c165_466 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim1.ios_sum c=2.57248e-15
c165_465 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim1.vbnc c=1.27988e-14
c165_451 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim1.net42 c=1.71228e-15
c165_450 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.nd4 c=1.51998e-14
c165_449 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.ns4 c=6.02369e-15
c165_447 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.nsdum c=7.77067e-15
c165_446 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.on_1 c=1.64266e-15
c165_445 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.onb_1 c=1.00194e-15
c165_444 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.on_2 c=1.77234e-15
c165_443 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.onb_2 c=1.0005e-15
c165_442 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.on_3 c=2.03906e-15
c165_441 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.onb_3 c=1.00227e-15
c165_440 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.on_4 c=3.61693e-15
c165_439 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.onb_4 c=1.01739e-15
c165_438 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.idac2atb_5v_b c=6.66431e-15
c165_437 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.idac2atb_5v_i c=2.07956e-15
c165_436 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.on_0 c=1.60244e-15
c165_435 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.net1521 c=1.06281e-15
c165_434 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.nd0 c=2.48159e-15
c165_431 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.nd1 c=1.12677e-15
c165_429 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.nd2 c=1.05453e-15
c165_428 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.ns2 c=1.27943e-15
c165_427 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.nd3 c=1.0644e-15
c165_426 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.ns3 c=2.55175e-15
c165_422 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim1.on_osb_3 c=3.41401e-15
c165_421 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim2.on_osb_3 c=3.03209e-15
c165_416 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.ls8.n_60 c=1.66794e-15
c165_415 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.ls8.n_59 c=4.12775e-15
c165_414 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls8.net106 c=3.98498e-15
c165_413 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls8.net104 c=7.6242e-15
c165_404 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.xst.net70 c=1.69765e-15
c165_402 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.cmp_out_dig c=1.25506e-15
c165_397 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.xst.net72 c=3.67294e-15
c165_396 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.n7 c=2.77935e-15
c165_395 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.xi106.p0 c=1.72614e-15
c165_392 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.iq_cmp.n_381 c=1.12166e-15
c165_391 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.n4 c=2.20782e-15
c165_385 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.n3 c=5.79578e-15
c165_375 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.net462 c=1.59848e-15
c165_374 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.n5 c=7.33079e-15
c165_373 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.n6 c=6.99273e-15
c165_370 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xhs_sup.vl5 c=2.19083e-15
c165_368 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xhs_sup.net176 c=1.96355e-15
c165_367 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xhs_sup.on_v5v_ana_i c=2.0106e-15
c165_366 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xhs_sup.on_v5v_ana_b c=1.99336e-15
c165_365 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xhs_sup.pdio_lv c=5.43483e-15
c165_362 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.hs_sup.n_343 c=1.05241e-15
c165_350 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.hs_sup.n_331 c=2.76059e-15
c165_348 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.hs_sup.n_329 c=1.19789e-15
c165_308 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.hs_sup.n_285 c=1.65308e-15
c165_298 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xhs_sup.vl4 c=1.25646e-15
c165_297 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xhs_sup.vr1 c=1.02393e-15
c165_282 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xdat2_cmp.data_comp_in c=1.62054e-15
c165_279 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xdat2_cmp.cmp_out_dig c=1.25614e-15
c165_278 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xdat2_cmp.xi106.p0 c=1.91909e-15
c165_277 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xdat2_cmp.xi232.x_u4-net13 c=1.50719e-15
c165_276 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xdat2_cmp.cmp_out_ana c=5.29466e-15
c165_275 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xdat2_cmp.n7 c=3.37491e-15
c165_274 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xdat2_cmp.on_v5v_ana_b c=1.16169e-15
c165_273 xdut.gnd_dsi xdut.xana.ln_dsi_ch1<0>.rx.dat2_cmp.n_367 c=1.10908e-15
c165_260 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xdat2_cmp.net462 c=1.46215e-15
c165_247 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xdat1_cmp.data_comp_in c=1.6184e-15
c165_244 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xdat1_cmp.cmp_out_dig c=1.25338e-15
c165_243 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xdat1_cmp.xi106.p0 c=1.91557e-15
c165_242 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xdat1_cmp.xi232.x_u4-net13 c=1.49476e-15
c165_241 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xdat1_cmp.cmp_out_ana c=5.30182e-15
c165_240 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xdat1_cmp.n7 c=3.4117e-15
c165_239 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xdat1_cmp.on_v5v_ana_b c=1.16636e-15
c165_233 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls9<4>.xd2a_hvpart_inst.net038 c=1.3705e-15
c165_231 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls9<2>.xd2a_hvpart_inst.net038 c=1.37788e-15
c165_229 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls9<1>.xd2a_hvpart_inst.net038 c=1.37491e-15
c165_227 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.idac_5v<1> c=4.78172e-15
c165_226 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.iq_cmp_5v c=1.75368e-14
c165_225 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.idac_5v<0> c=4.8936e-15
c165_224 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.idac_5v<2> c=5.42191e-15
c165_222 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls4<3>.ls_a c=1.04715e-15
c165_220 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls4<2>.ls_a c=1.03577e-15
c165_218 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls4<1>.ls_a c=1.04223e-15
c165_216 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls4<0>.ls_a c=1.04759e-15
c165_214 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls5<3>.ls_a c=1.04848e-15
c165_212 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls5<2>.ls_a c=1.04481e-15
c165_209 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls5<1>.ls_a c=1.04842e-15
c165_208 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls5<0>.ls_a c=1.05183e-15
c165_206 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls7.ls_a c=1.05498e-15
c165_193 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.inp_iqcmp c=5.8186e-15
c165_192 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.net899 c=1.48505e-15
c165_190 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.nd2_cs c=4.07957e-15
c165_182 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.on_v5v_ana_b c=8.69245e-15
c165_181 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.on_v5v_ana_i c=6.12479e-15
c165_173 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.nbias_os_cas c=2.80193e-14
c165_172 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.nbias_os c=7.50744e-14
c165_171 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.inn_iqcmp c=1.0363e-14
c165_170 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.nd7_cs c=5.17837e-15
c165_169 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.nd8_cs c=8.0357e-15
c165_168 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.nd6_cs c=7.43458e-15
c165_167 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.nd4_cs c=2.13345e-15
c165_166 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.nbias_cs c=1.13575e-13
c165_165 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.nd5_cs c=3.83665e-15
c165_164 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.nd3_cs c=2.39367e-15
c165_162 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls1.xd2a_hvpart_inst.net038 c=1.45257e-15
c165_159 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.trim_dcmp1_5v<3> c=5.73043e-15
c165_152 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.trim_dcmp1_5v<2> c=4.86718e-15
c165_151 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls4<3>.xd2a_hvpart_inst.net038 c=1.41684e-15
c165_146 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls4<2>.xd2a_hvpart_inst.net038 c=1.41515e-15
c165_145 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls4<1>.xd2a_hvpart_inst.net038 c=1.41659e-15
c165_143 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.trim_dcmp1_5v<1> c=5.15495e-15
c165_139 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls4<0>.xd2a_hvpart_inst.net038 c=1.41624e-15
c165_137 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.trim_dcmp1_5v<0> c=1.15209e-14
c165_136 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.trim_dcmp2_5v<3> c=4.69418e-15
c165_131 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls5<3>.xd2a_hvpart_inst.net038 c=1.41528e-15
c165_129 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.trim_dcmp2_5v<2> c=3.37758e-15
c165_123 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls5<2>.xd2a_hvpart_inst.net038 c=1.41573e-15
c165_120 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.trim_dcmp2_5v<1> c=3.09705e-15
c165_116 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls5<1>.xd2a_hvpart_inst.net038 c=1.42595e-15
c165_115 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls5<0>.xd2a_hvpart_inst.net038 c=1.39808e-15
c165_113 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.trim_dcmp2_5v<0> c=6.0579e-15
c165_112 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.flt_fast_5v c=1.5703e-14
c165_111 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_lvl_in_0.xi_tx_cfg<0>.pull_up c=1.14634e-15
c165_108 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls7.xd2a_hvpart_inst.net038 c=1.46968e-15
c165_100 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls9<0>.xd2a_hvpart_inst.net038 c=1.42009e-15
c165_98 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls9<3>.xd2a_hvpart_inst.net038 c=1.40314e-15
c165_96 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_lvl_in_0.xi_tx_cfg<2>.pull_up c=1.08272e-15
c165_95 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_lvl_in_0.xi_on_tx.pull_up c=1.09529e-15
c165_89 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.idac_5v<4> c=2.40752e-15
c165_88 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.idac_5v<3> c=3.31592e-15
c165_87 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.idac2atb_5v c=1.12683e-14
c165_86 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_lvl_in_0.xi_tx_cfg<1>.pull_up c=1.08191e-15
c165_85 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_lvl_in_0.xi_on_tx_casc.pull_up c=1.10158e-15
c165_82 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_lvl_in_0.xi_atst_tx<5>.pull_up c=1.08794e-15
c165_81 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls8.net107 c=6.58959e-15
c165_78 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls6.xd2a_hvpart_inst.net038 c=1.3731e-15
c165_76 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.dat2_sw_d c=2.13561e-14
c165_75 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.dat1_sw_d c=1.62402e-14
c165_73 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vpnc1 c=6.56457e-14
c165_71 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_lvl_in_0.xi_tx_data<3>.pull_up c=1.15127e-15
c165_70 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xtx_lvl_in_0.xi_atst_tx<1>.pull_up c=1.15205e-15
c165_69 xdut.gnd_dsi xdut.xana.net875 c=8.16192e-15
c165_67 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xls1.ls_a c=1.04997e-15
c165_63 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xls1.ls_a c=1.05342e-15
c165_59 xdut.gnd_dsi xdut.trim_dsi_rx2<5> c=1.21781e-15
c165_58 xdut.gnd_dsi xdut.trim_dsi_rx2<6> c=1.22806e-15
c165_57 xdut.gnd_dsi xdut.trim_dsi_rx1<5> c=1.17335e-15
c165_56 xdut.gnd_dsi xdut.trim_dsi_rx1<4> c=1.16355e-15
c165_55 xdut.gnd_dsi xdut.trim_dsi_rx2<7> c=1.21882e-15
c165_54 xdut.gnd_dsi xdut.trim_dsi_rx1<6> c=1.22594e-15
c165_53 xdut.gnd_dsi xdut.dsi_rx_on<1> c=1.20503e-15
c165_52 xdut.gnd_dsi xdut.trim_dsi_rx1<7> c=1.21339e-15
c165_51 xdut.gnd_dsi xdut.atst_rx<1> c=1.25134e-15
c165_50 xdut.gnd_dsi xdut.dsi_rxd2<1> c=1.44215e-15
c165_49 xdut.gnd_dsi xdut.dsi_rx_filter_fast<1> c=1.43481e-15
c165_48 xdut.gnd_dsi xdut.dsi_rxd1<1> c=1.27761e-15
c165_47 xdut.gnd_dsi xdut.dsi_tx_tbit_cfg<3> c=2.60351e-15
c165_46 xdut.gnd_dsi xdut.atst_tx<13> c=2.44608e-15
c165_44 xdut.gnd_dsi xdut.dsi_rx_txn<1> c=2.78216e-15
c165_43 xdut.gnd_dsi xdut.dsi_tx_data<9> c=1.18327e-15
c165_42 xdut.gnd_dsi xdut.dsi_tx_tbit_cfg<2> c=2.89118e-15
c165_41 xdut.gnd_dsi xdut.dsi_idac<7> c=1.97698e-15
c165_40 xdut.gnd_dsi xdut.dsi_idac<8> c=1.91791e-15
c165_39 xdut.gnd_dsi xdut.dsi_idac<5> c=1.59102e-15
c165_38 xdut.gnd_dsi xdut.dsi_idac<9> c=2.03273e-15
c165_36 xdut.gnd_dsi xdut.dsi_icmp<1> c=1.2786e-15
c165_35 xdut.gnd_dsi xdut.dsi_tx_data<7> c=1.45116e-15
c165_34 xdut.gnd_dsi xdut.dsi_tx_data<8> c=1.23604e-15
c165_33 xdut.gnd_dsi xdut.dsi_tx_data<5> c=2.03632e-15
c165_32 xdut.gnd_dsi xdut.dsi_tx_data<6> c=1.70713e-15
c165_31 xdut.gnd_dsi xdut.xana.xldo.vdsi_fc c=5.74339e-15
c165_30 xdut.gnd_dsi xdut.xana.xldo.vs_m0 c=3.16689e-15
c165_29 xdut.gnd_dsi xdut.xana.xldo.vbp_lim c=2.16816e-14
c165_28 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.offs_sw_d c=1.65967e-14
c165_27 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.isum c=8.0395e-15
c165_26 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.isum c=6.5851e-15
c165_25 xdut.gnd_dsi xdut.xana.xldo.vdsi_nbl c=2.44862e-14
c165_20 xdut.gnd_dsi xdut.dsi0_p c=2.2205e-12
c165_19 xdut.gnd_dsi xdut.dsi1_p c=2.21799e-12
c165_10 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.vsup_dsi c=9.95869e-13
c165_9 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.vsup_dsi c=1.00226e-12
c165_8 xdut.gnd_dsi xdut.cldo_p c=2.46656e-12
c165_7 xdut.gnd_dsi xdut.vsup_p c=1.4911e-12
c165_6 xdut.gnd_dsi xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd c=1.08932e-12
c165_5 xdut.gnd_dsi xdut.gnd_p c=1.3032e-12
c165_4 xdut.gnd_dsi xdut.dgnd_p c=7.58703e-15
c165_3 xdut.gnd_dsi xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=4.13903e-12
c165_2 xdut.gnd_dsi xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.90876e-13
c165_1 xdut.gnd_dsi xdut.vio_p c=1.53305e-15
cg24_21 xdut.clkref_p 0 c=6.67386e-14
c24_6 xdut.clkref_p xdut.xpad1.gnstrong c=6.12302e-15
c24_5 xdut.clkref_p xdut.xpad1.gpstrong c=1.98099e-14
c24_3 xdut.clkref_p xdut.dgnd_p c=2.92428e-13
c24_2 xdut.clkref_p xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.82072e-14
c24_1 xdut.clkref_p xdut.vio_p c=2.4511e-13
cg23_22 xdut.rfc_p 0 c=6.5923e-14
c23_14 xdut.rfc_p xdut.xpad18.gpesd c=1.28539e-14
c23_13 xdut.rfc_p xdut.xpad18.gnesd c=3.66356e-14
c23_9 xdut.rfc_p xdut.rfc_oe c=1.21079e-15
c23_8 xdut.rfc_p xdut.rfc_o c=1.236e-15
c23_7 xdut.rfc_p xdut.rfc_pu c=1.19753e-15
c23_6 xdut.rfc_p xdut.rfc_pd c=1.2089e-15
c23_5 xdut.rfc_p xdut.rfc_ie c=1.21538e-15
c23_4 xdut.rfc_p xdut.rfc_i c=1.19971e-15
c23_3 xdut.rfc_p xdut.dgnd_p c=2.92083e-13
c23_2 xdut.rfc_p xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=2.4846e-14
c23_1 xdut.rfc_p xdut.vio_p c=2.45447e-13
cg21_61 xdut.dsi0_p 0 c=9.43415e-14
c21_54 xdut.dsi0_p xdut.xana.ln_dsi_ch1<0>.tx.tx_amp_fb_0.tx_amp_rdiv_out.n_10 c=2.75932e-15
c21_52 xdut.dsi0_p xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.inn_5v c=1.85951e-15
c21_46 xdut.dsi0_p xdut.xana.xdsi_ch1<0>.xtx.atst_tx_5v<6> c=1.53481e-15
c21_44 xdut.dsi0_p xdut.xana.xdsi_ch1<0>.xtx.tx_cfg_5v<1> c=1.42678e-15
c21_39 xdut.dsi0_p xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_95 c=1.53673e-15
c21_38 xdut.dsi0_p xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_94 c=1.4566e-15
c21_36 xdut.dsi0_p xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_92 c=1.98913e-15
c21_33 xdut.dsi0_p xdut.xana.xdsi_ch1<0>.xrx.xrshunt.net1142 c=1.70754e-15
c21_32 xdut.dsi0_p xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_89 c=1.45649e-15
c21_30 xdut.dsi0_p xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_87 c=1.53603e-15
c21_29 xdut.dsi0_p xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_86 c=1.45663e-15
c21_27 xdut.dsi0_p xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_84 c=1.82553e-15
c21_25 xdut.dsi0_p xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_82 c=1.45633e-15
c21_22 xdut.dsi0_p xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_76 c=1.44597e-15
c21_21 xdut.dsi0_p xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_75 c=1.457e-15
c21_19 xdut.dsi0_p xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_73 c=1.98923e-15
c21_17 xdut.dsi0_p xdut.xana.xdsi_ch1<0>.xrx.xrshunt.net1147 c=1.36536e-15
c21_15 xdut.dsi0_p xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_65 c=1.16394e-15
c21_14 xdut.dsi0_p xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_64 c=1.82573e-15
c21_13 xdut.dsi0_p xdut.xana.xdsi_ch1<0>.xrx.xrshunt.net1153 c=1.42708e-15
c21_11 xdut.dsi0_p xdut.xana.xdsi_ch1<0>.xrx.xrshunt.net1145 c=4.30729e-15
c21_8 xdut.dsi0_p xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_22 c=1.7751e-15
c21_7 xdut.dsi0_p xdut.xana.xdsi_ch1<0>.xrx.xrshunt.net1139 c=8.2132e-15
c21_5 xdut.dsi0_p xdut.xana.ln_dsi_ch1<0>.rx.rshunt.n_103 c=1.53939e-15
c21_1 xdut.dsi0_p xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.34926e-15
cg20_61 xdut.dsi1_p 0 c=8.91956e-14
c20_54 xdut.dsi1_p xdut.xana.ln_dsi_ch1<1>.tx.tx_amp_fb_0.tx_amp_rdiv_out.n_10 c=2.75932e-15
c20_52 xdut.dsi1_p xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.inn_5v c=1.85975e-15
c20_45 xdut.dsi1_p xdut.xana.xdsi_ch1<1>.xtx.atst_tx_5v<6> c=1.53481e-15
c20_41 xdut.dsi1_p xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_95 c=1.53673e-15
c20_40 xdut.dsi1_p xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_94 c=1.4566e-15
c20_38 xdut.dsi1_p xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_92 c=1.98913e-15
c20_35 xdut.dsi1_p xdut.xana.xdsi_ch1<1>.xrx.xrshunt.net1142 c=1.70761e-15
c20_34 xdut.dsi1_p xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_89 c=1.45649e-15
c20_32 xdut.dsi1_p xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_87 c=1.53603e-15
c20_31 xdut.dsi1_p xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_86 c=1.45663e-15
c20_29 xdut.dsi1_p xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_84 c=1.82553e-15
c20_27 xdut.dsi1_p xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_82 c=1.45633e-15
c20_24 xdut.dsi1_p xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_76 c=1.44597e-15
c20_23 xdut.dsi1_p xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_75 c=1.457e-15
c20_21 xdut.dsi1_p xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_73 c=1.98923e-15
c20_19 xdut.dsi1_p xdut.xana.xdsi_ch1<1>.xrx.xrshunt.net1147 c=1.36536e-15
c20_17 xdut.dsi1_p xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_65 c=1.16394e-15
c20_16 xdut.dsi1_p xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_64 c=1.82573e-15
c20_15 xdut.dsi1_p xdut.xana.xdsi_ch1<1>.xrx.xrshunt.net1153 c=1.42708e-15
c20_13 xdut.dsi1_p xdut.xana.xdsi_ch1<1>.xrx.xrshunt.net1145 c=4.30717e-15
c20_10 xdut.dsi1_p xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_22 c=1.7751e-15
c20_9 xdut.dsi1_p xdut.xana.xdsi_ch1<1>.xrx.xrshunt.net1139 c=8.21161e-15
c20_7 xdut.dsi1_p xdut.xana.ln_dsi_ch1<1>.rx.rshunt.n_103 c=1.53939e-15
c20_1 xdut.dsi1_p xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.34845e-15
cg11_31 xdut.xana.xdsi_ch1<0>.vsup_dsi 0 c=7.23199e-12
c11_8 xdut.xana.xdsi_ch1<0>.vsup_dsi xdut.xana.xdsi_ch1<0>.xtx.vdsi_ov_5v c=1.87359e-15
c11_1 xdut.xana.xdsi_ch1<0>.vsup_dsi xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.02019e-15
cg10_20 xdut.xana.xdsi_ch1<1>.vsup_dsi 0 c=7.23335e-12
c10_3 xdut.xana.xdsi_ch1<1>.vsup_dsi xdut.xana.xdsi_ch1<1>.xtx.vdsi_ov_5v c=1.87936e-15
c10_1 xdut.xana.xdsi_ch1<1>.vsup_dsi xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.01959e-15
cg9_6 xdut.aout_p 0 c=4.84851e-14
c9_3 xdut.aout_p xdut.gnd_p c=4.18827e-15
c9_2 xdut.aout_p xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=3.18477e-13
c9_1 xdut.aout_p xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=3.32145e-14
cg8_196 xdut.cldo_p 0 c=2.3599e-12
c8_71 xdut.cldo_p xdut.xana.xldo.s_cas2 c=2.05747e-15
c8_62 xdut.cldo_p xdut.xana.xldo.vd_msen c=1.19382e-15
c8_44 xdut.cldo_p xdut.xana.xldo.vd_m0 c=3.83985e-15
c8_35 xdut.cldo_p xdut.xana.xldo.ota_out c=1.40649e-15
c8_8 xdut.cldo_p xdut.xana.xldo.vdsi_fc c=9.18339e-15
c8_7 xdut.cldo_p xdut.xana.xldo.vs_m0 c=5.2654e-15
c8_5 xdut.cldo_p xdut.xana.xldo.vdsi_nbl c=1.18566e-14
c8_4 xdut.cldo_p xdut.vsup_p c=1.42937e-12
c8_3 xdut.cldo_p xdut.gnd_p c=2.50564e-13
c8_2 xdut.cldo_p xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=1.57074e-13
c8_1 xdut.cldo_p xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=8.80227e-15
cg7_36 xdut.vsup_p 0 c=2.8845e-12
c7_35 xdut.vsup_p xdut.xana.xsup.xvddreg.xvddreg.vs_cl c=1.51211e-15
c7_33 xdut.vsup_p xdut.xana.xsup.xvccreg.xreg.net1107 c=1.28025e-15
c7_25 xdut.vsup_p xdut.xana.xldo.s_cas1 c=2.05341e-15
c7_22 xdut.vsup_p xdut.xana.xldo.net634 c=3.99592e-14
c7_21 xdut.vsup_p xdut.xana.xldo.net640 c=1.06311e-14
c7_20 xdut.vsup_p xdut.xana.xldo.vgsen c=9.24728e-15
c7_19 xdut.vsup_p xdut.xana.xldo.vd_msen c=2.33332e-15
c7_18 xdut.vsup_p xdut.xana.xldo.vd_m0 c=1.10252e-15
c7_9 xdut.vsup_p xdut.xana.xldo.ota_out c=2.65248e-15
c7_5 xdut.vsup_p xdut.xana.xldo.vdsi_fc c=1.39535e-14
c7_4 xdut.vsup_p xdut.xana.xldo.vbp_lim c=3.64031e-15
c7_3 xdut.vsup_p xdut.xana.xsup.xvccreg.xreg.vbat c=3.89306e-14
c7_2 xdut.vsup_p xdut.gnd_p c=2.01128e-13
c7_1 xdut.vsup_p xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=9.94313e-13
cg6_236 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd 0 c=5.70877e-14
c6_172 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xls8.net106 c=9.76796e-15
c6_171 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xls8.net104 c=1.87123e-15
c6_155 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.vbn c=1.51072e-14
c6_154 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.vbp c=2.10416e-15
c6_152 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.ln_dsi_ch1<0>.rx.iq_cmp.n_381 c=1.195e-15
c6_151 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.n4 c=3.67047e-15
c6_145 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.n3 c=6.51536e-15
c6_142 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.ln_dsi_ch1<0>.rx.iq_cmp.n_235 c=4.46912e-15
c6_141 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.n2 c=3.28686e-15
c6_140 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.n1 c=3.19121e-15
c6_136 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.n5 c=1.86479e-15
c6_135 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.n6 c=1.96448e-15
c6_123 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xhs_sup.vr4 c=1.59432e-15
c6_120 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xflt3.net25 c=2.12642e-15
c6_119 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xflt3.net15 c=2.07508e-15
c6_118 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xflt3.net6 c=2.00068e-15
c6_117 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xflt3.net84 c=1.64859e-15
c6_116 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xflt3.net28 c=2.02084e-15
c6_115 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xflt3.net83 c=1.67012e-15
c6_114 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xflt3.inn_1 c=5.63315e-15
c6_113 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xflt3.inp_1 c=5.43711e-15
c6_112 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xflt2.net25 c=2.13567e-15
c6_111 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xflt2.net15 c=2.08754e-15
c6_110 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xflt2.net6 c=2.00315e-15
c6_109 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xflt2.net84 c=1.63447e-15
c6_108 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xflt2.net28 c=2.02348e-15
c6_107 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xflt2.net83 c=1.66756e-15
c6_106 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xflt2.inn_1 c=6.77792e-15
c6_105 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xflt2.inp_1 c=6.95523e-15
c6_104 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xflt1.net25 c=2.11879e-15
c6_103 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xflt1.net15 c=2.15642e-15
c6_102 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xflt1.net6 c=2.00286e-15
c6_101 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xflt1.net84 c=1.64165e-15
c6_100 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xflt1.net28 c=2.01924e-15
c6_99 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xflt1.net83 c=1.6348e-15
c6_98 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xflt1.inn_1 c=6.80496e-15
c6_76 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xdat2_cmp.vbn c=2.28891e-14
c6_75 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xdat2_cmp.vbp c=6.35237e-15
c6_73 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.ln_dsi_ch1<0>.rx.dat2_cmp.n_367 c=1.90315e-15
c6_64 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.ln_dsi_ch1<0>.rx.dat2_cmp.n_224 c=4.53761e-15
c6_32 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.inp_iqcmp c=1.00017e-13
c6_31 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.net899 c=5.28565e-15
c6_22 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.inn_iqcmp c=1.03409e-13
c6_6 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.flt_fast_5v c=6.18506e-15
c6_5 xdut.xana.xdsi_ch1<0>.xrx.vhs_gnd xdut.xana.xdsi_ch1<0>.xrx.xls8.net107 c=1.21461e-14
cg5_1076 xdut.gnd_p 0 c=1.2332e-11
c5_1075 xdut.gnd_p xdut.xpad6_gnd.net24 c=1.02041e-14
c5_1074 xdut.gnd_p xdut.xpad6_gnd.net_1 c=4.11664e-14
c5_1069 xdut.gnd_p xdut.xana.xtmon.xcomp2.nn1 c=1.91898e-15
c5_1065 xdut.gnd_p xdut.xana.xtmon.xcomp1.nn1 c=1.86403e-15
c5_1063 xdut.gnd_p xdut.xana.xsup.xls3<1>.pull_up c=1.05517e-15
c5_1058 xdut.gnd_p xdut.xana.xtmon.xls1<0>.xd2a_hvpart_inst.net038 c=1.34957e-15
c5_1056 xdut.gnd_p xdut.xana.xtmon.xls1<1>.xd2a_hvpart_inst.net038 c=1.35837e-15
c5_1054 xdut.gnd_p xdut.xana.xtmon.adj_ot_5v<0> c=1.25014e-15
c5_1052 xdut.gnd_p xdut.xana.xtmon.adj_ot__5v_1n c=1.05091e-15
c5_1051 xdut.gnd_p xdut.xana.xsup.xls3<3>.pull_up c=1.06144e-15
c5_1046 xdut.gnd_p xdut.xana.xtmon.xls4<0>.xd2a_hvpart_inst.net038 c=1.36065e-15
c5_1044 xdut.gnd_p xdut.xana.xtmon.xls4<1>.xd2a_hvpart_inst.net038 c=1.34564e-15
c5_1042 xdut.gnd_p xdut.xana.xsup.xls3<2>.pull_up c=1.05877e-15
c5_1041 xdut.gnd_p xdut.xana.xsup.xls3<4>.pull_up c=1.05678e-15
c5_1040 xdut.gnd_p xdut.xana.xtmon.v_tsens_i c=6.63215e-14
c5_1036 xdut.gnd_p xdut.xana.xtmon.net664 c=1.44026e-15
c5_1035 xdut.gnd_p xdut.xana.xtmon.net666 c=1.01128e-15
c5_1034 xdut.gnd_p xdut.xana.xtmon.xcomp1.enb c=1.87419e-15
c5_1032 xdut.gnd_p xdut.xana.ln_tmon.n_349 c=3.32591e-15
c5_1031 xdut.gnd_p xdut.xana.xtmon.vref_ot_on c=1.06962e-14
c5_1030 xdut.gnd_p xdut.xana.xtmon.net733 c=3.85445e-15
c5_1029 xdut.gnd_p xdut.xana.ln_tmon.n_346 c=3.26525e-15
c5_1028 xdut.gnd_p xdut.xana.ln_tmon.n_345 c=3.31773e-15
c5_1027 xdut.gnd_p xdut.xana.ln_tmon.n_344 c=3.27629e-15
c5_1026 xdut.gnd_p xdut.xana.ln_tmon.n_343 c=3.24114e-15
c5_1025 xdut.gnd_p xdut.xana.ln_tmon.n_342 c=3.36375e-15
c5_1024 xdut.gnd_p xdut.xana.ln_tmon.n_341 c=3.29989e-15
c5_1023 xdut.gnd_p xdut.xana.ln_tmon.n_340 c=3.33184e-15
c5_1022 xdut.gnd_p xdut.xana.ln_tmon.n_339 c=3.29378e-15
c5_1021 xdut.gnd_p xdut.xana.ln_tmon.n_338 c=3.37349e-15
c5_1020 xdut.gnd_p xdut.xana.ln_tmon.n_337 c=3.5678e-15
c5_1019 xdut.gnd_p xdut.xana.ln_tmon.n_336 c=3.22175e-15
c5_1018 xdut.gnd_p xdut.xana.ln_tmon.n_335 c=3.40191e-15
c5_1017 xdut.gnd_p xdut.xana.ln_tmon.n_334 c=3.3025e-15
c5_1016 xdut.gnd_p xdut.xana.ln_tmon.n_333 c=3.30531e-15
c5_1015 xdut.gnd_p xdut.xana.ln_tmon.n_332 c=3.32802e-15
c5_1014 xdut.gnd_p xdut.xana.ln_tmon.n_331 c=3.28981e-15
c5_1013 xdut.gnd_p xdut.xana.ln_tmon.n_330 c=3.30681e-15
c5_1012 xdut.gnd_p xdut.xana.ln_tmon.n_329 c=3.30623e-15
c5_1011 xdut.gnd_p xdut.xana.ln_tmon.n_328 c=6.65888e-15
c5_1010 xdut.gnd_p xdut.xana.ln_tmon.n_327 c=3.27809e-15
c5_1009 xdut.gnd_p xdut.xana.ln_tmon.n_326 c=3.26639e-15
c5_1008 xdut.gnd_p xdut.xana.xtmon.net766 c=3.27058e-15
c5_1007 xdut.gnd_p xdut.xana.xtmon.vref_warn_on c=1.37661e-14
c5_1006 xdut.gnd_p xdut.xana.xtmon.vref_warn_off c=8.8236e-15
c5_1002 xdut.gnd_p xdut.xana.xtmon.xcomp2.xi25.intern c=1.6872e-15
c5_1000 xdut.gnd_p xdut.xana.xtmon.xsw1.net28 c=1.89768e-15
c5_999 xdut.gnd_p xdut.xana.xtmon.xsw1.en_int c=1.6151e-15
c5_998 xdut.gnd_p xdut.xana.xtmon.xsw1.enb_int c=1.8537e-15
c5_997 xdut.gnd_p xdut.xana.xtmon.net699 c=2.31507e-15
c5_996 xdut.gnd_p xdut.xana.xtmon.net544 c=1.66602e-15
c5_995 xdut.gnd_p xdut.xana.xtmon.v_tsens c=2.25942e-15
c5_994 xdut.gnd_p xdut.xana.xtmon.net665 c=2.09885e-15
c5_993 xdut.gnd_p xdut.xana.xtmon.xsw2.net28 c=1.88637e-15
c5_992 xdut.gnd_p xdut.xana.xtmon.xsw2.en_int c=1.6051e-15
c5_991 xdut.gnd_p xdut.xana.xtmon.xsw2.enb_int c=1.64645e-15
c5_988 xdut.gnd_p xdut.xana.xtmon.net740 c=4.96328e-15
c5_982 xdut.gnd_p xdut.xana.xtmon.xcomp1.xi25.intern c=1.69776e-15
c5_979 xdut.gnd_p xdut.xana.xtmon.otwarn_5v c=3.43117e-15
c5_977 xdut.gnd_p xdut.xana.xtmon.net690 c=4.71777e-14
c5_976 xdut.gnd_p xdut.xana.xtmon.xcomp2.nn4 c=1.35208e-15
c5_975 xdut.gnd_p xdut.xana.xtmon.xcomp2.nn3 c=3.75868e-15
c5_974 xdut.gnd_p xdut.xana.xtmon.xcomp2.nn2 c=4.60603e-15
c5_969 xdut.gnd_p xdut.xana.xtmon.xcomp1.nn6 c=5.67804e-15
c5_968 xdut.gnd_p xdut.xana.xtmon.net680 c=5.66711e-15
c5_966 xdut.gnd_p xdut.xana.xtmon.net687 c=4.94611e-14
c5_965 xdut.gnd_p xdut.xana.xtmon.xcomp1.nn4 c=1.31776e-15
c5_964 xdut.gnd_p xdut.xana.xtmon.xcomp1.nnvc c=8.3284e-14
c5_963 xdut.gnd_p xdut.xana.xtmon.xcomp1.nn3 c=3.75166e-15
c5_962 xdut.gnd_p xdut.xana.xtmon.xcomp1.nn2 c=4.60795e-15
c5_961 xdut.gnd_p xdut.xana.xtmon.xcomp1.net60 c=2.26828e-15
c5_960 xdut.gnd_p xdut.xana.xtmon.net745 c=8.7209e-15
c5_959 xdut.gnd_p xdut.xana.xtmon.atst_ts_5v<0> c=1.15505e-15
c5_956 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<99> c=1.90132e-15
c5_946 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<8> c=1.2237e-15
c5_924 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<6> c=1.21877e-15
c5_903 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<4> c=1.20118e-15
c5_901 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<48> c=1.23268e-15
c5_899 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<46> c=1.18205e-15
c5_897 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<44> c=1.23764e-15
c5_895 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<42> c=1.2162e-15
c5_893 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<40> c=1.22031e-15
c5_890 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<38> c=1.21171e-15
c5_888 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<36> c=1.21192e-15
c5_887 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<34> c=1.21786e-15
c5_885 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<32> c=1.18665e-15
c5_883 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<30> c=1.2103e-15
c5_882 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<2> c=1.47562e-15
c5_880 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<26> c=1.21571e-15
c5_879 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<24> c=1.19284e-15
c5_877 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<22> c=1.21488e-15
c5_875 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<20> c=1.22744e-15
c5_874 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<1> c=2.02004e-15
c5_872 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<18> c=1.19065e-15
c5_870 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<16> c=1.20881e-15
c5_868 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<14> c=1.17576e-15
c5_866 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<12> c=1.22176e-15
c5_864 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<10> c=1.19961e-15
c5_863 xdut.gnd_p xdut.xana.xsup.xvrrmon.xrdiv.net113 c=1.0796e-15
c5_862 xdut.gnd_p xdut.xana.xsup.xvccreg.xrdiv_vdda.net132 c=1.02156e-15
c5_853 xdut.gnd_p xdut.xana.xsup.xvrrmon.xcomp2.nn1 c=1.84873e-15
c5_849 xdut.gnd_p xdut.xana.xsup.xvrrmon.xcomp1.nn1 c=1.88613e-15
c5_846 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<28> c=1.17588e-15
c5_844 xdut.gnd_p xdut.xana.xsup.xvrrmon.xcomp1.nn3 c=3.79532e-15
c5_842 xdut.gnd_p xdut.xana.xsup.xvrrmon.net52 c=1.94629e-14
c5_841 xdut.gnd_p xdut.xana.xsup.xvrrmon.xcomp1.nn4 c=1.36244e-15
c5_840 xdut.gnd_p xdut.xana.xsup.xvrrmon.xcomp1.nnvc c=3.42508e-14
c5_839 xdut.gnd_p xdut.xana.xsup.xvrrmon.xcomp1.nn2 c=4.63311e-15
c5_835 xdut.gnd_p xdut.xana.xsup.xvrrmon.xcomp1.xi25.intern c=1.6873e-15
c5_832 xdut.gnd_p xdut.xana.xsup.xvrrmon.xcomp1.enb c=1.86941e-15
c5_831 xdut.gnd_p xdut.xana.xsup.xvrrmon.xcomp2.enb c=1.86738e-15
c5_830 xdut.gnd_p xdut.xana.xsup.xvrrmon.ena c=1.86902e-15
c5_828 xdut.gnd_p xdut.xana.xsup.xvrrmon.vrr_int c=1.09253e-14
c5_827 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<52> c=2.69755e-15
c5_826 xdut.gnd_p xdut.xana.xsup.xvrrmon.rdiv<35> c=5.48162e-15
c5_821 xdut.gnd_p xdut.xana.xsup.xvrrmon.xcomp2.xi25.intern c=1.68246e-15
c5_819 xdut.gnd_p xdut.xana.xsup.xvrrmon.xcomp2.nn2 c=4.62587e-15
c5_817 xdut.gnd_p xdut.xana.xsup.xvrrmon.net18 c=2.32371e-15
c5_816 xdut.gnd_p xdut.xana.xsup.xvrrmon.xcomp2.nn3 c=3.7878e-15
c5_814 xdut.gnd_p xdut.xana.xsup.xvrrmon.net54 c=1.41638e-14
c5_813 xdut.gnd_p xdut.xana.xsup.xvrrmon.xcomp2.nn4 c=1.33831e-15
c5_812 xdut.gnd_p xdut.xana.xsup.xvrrmon.xcomp2.nnvc c=3.42408e-14
c5_811 xdut.gnd_p xdut.xana.xsup.xvrrmon.xcomp2.nn6 c=5.65008e-15
c5_810 xdut.gnd_p xdut.xana.xsup.xvrrmon.xcomp2.net60 c=2.06918e-15
c5_809 xdut.gnd_p xdut.xana.xsup.xvrrmon.xcomp1.nn6 c=5.64336e-15
c5_808 xdut.gnd_p xdut.xana.xsup.xvrrmon.xcomp1.net60 c=2.07312e-15
c5_790 xdut.gnd_p xdut.xana.xsup.xvddreg.xvddreg.net326 c=3.09593e-13
c5_788 xdut.gnd_p xdut.xana.xsup.xvddreg.xvddreg.net392 c=1.10608e-15
c5_787 xdut.gnd_p xdut.xana.xsup.xvddreg.xvddreg.net379 c=3.18352e-15
c5_786 xdut.gnd_p xdut.xana.xsup.xvddreg.xvddreg.gate c=5.12551e-13
c5_785 xdut.gnd_p xdut.xana.xsup.xvddreg.xvddreg.vref_flt c=3.13455e-14
c5_782 xdut.gnd_p xdut.xana.xsup.xvddreg.xvddreg.vfbi c=2.20758e-14
c5_781 xdut.gnd_p xdut.xana.xsup.xvddreg.xvddreg.net356 c=1.64747e-14
c5_780 xdut.gnd_p xdut.xana.xsup.xvddreg.xvddreg.net385 c=1.68651e-15
c5_779 xdut.gnd_p xdut.xana.xsup.xvddreg.xvddreg.vgfb c=3.11833e-15
c5_778 xdut.gnd_p xdut.xana.xsup.xvddreg.xvddreg.reg_en c=3.98507e-15
c5_777 xdut.gnd_p xdut.xana.xsup.xvddreg.xvddreg.vs_cl c=6.21139e-15
c5_776 xdut.gnd_p xdut.xana.xsup.xvddreg.xvddreg.net377 c=4.89622e-15
c5_775 xdut.gnd_p xdut.xana.xsup.xvccreg.xreg.nbl1 c=6.93737e-14
c5_774 xdut.gnd_p xdut.xana.xsup.xvddreg.xvddreg.net221 c=1.38289e-15
c5_773 xdut.gnd_p xdut.xana.xsup.xvddreg.xvddreg.net354 c=1.10356e-15
c5_772 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<9> c=1.76557e-15
c5_771 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<8> c=1.63265e-15
c5_770 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<7> c=1.77352e-15
c5_769 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<6> c=1.63932e-15
c5_768 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<5> c=1.77352e-15
c5_767 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<4> c=1.62382e-15
c5_766 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<3> c=1.77387e-15
c5_765 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<39> c=1.63079e-15
c5_764 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<38> c=1.82019e-15
c5_763 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<37> c=1.63088e-15
c5_762 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<36> c=1.82493e-15
c5_761 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<35> c=1.63078e-15
c5_760 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<34> c=1.80116e-15
c5_759 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<32> c=1.81245e-15
c5_758 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<30> c=1.82118e-15
c5_757 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<2> c=1.63839e-15
c5_756 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<29> c=1.61594e-15
c5_755 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<27> c=1.6141e-15
c5_754 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<26> c=1.78546e-15
c5_753 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<25> c=1.61557e-15
c5_752 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<24> c=1.80402e-15
c5_751 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<23> c=1.61773e-15
c5_750 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<22> c=1.84682e-15
c5_749 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<21> c=1.61651e-15
c5_748 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<20> c=1.63173e-15
c5_747 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<1> c=1.77059e-15
c5_746 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<19> c=1.75736e-15
c5_745 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<18> c=1.6324e-15
c5_744 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<17> c=1.76731e-15
c5_743 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<16> c=1.63104e-15
c5_742 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<15> c=1.75306e-15
c5_741 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<14> c=1.63024e-15
c5_740 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<13> c=1.76628e-15
c5_739 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<12> c=1.63024e-15
c5_738 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<11> c=1.75834e-15
c5_737 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<10> c=1.63086e-15
c5_736 xdut.gnd_p xdut.xana.xsup.xvddreg.xrdiv.net118 c=7.0967e-15
c5_726 xdut.gnd_p xdut.xana.xsup.xvddreg.xcomp.net60 c=2.15076e-15
c5_725 xdut.gnd_p xdut.xana.xsup.xvddreg.xcomp.enb c=1.85997e-15
c5_724 xdut.gnd_p xdut.xana.xsup.xvddreg.net129 c=8.90017e-15
c5_723 xdut.gnd_p xdut.xana.xsup.xvddreg.xcomp.nn4 c=1.34198e-15
c5_722 xdut.gnd_p xdut.xana.xsup.xvddreg.xcomp.nn6 c=5.72176e-15
c5_721 xdut.gnd_p xdut.xana.xsup.xvddreg.ibn1u c=5.48817e-15
c5_719 xdut.gnd_p xdut.xana.xsup.xvddreg.xcomp.nnvc c=3.6211e-14
c5_717 xdut.gnd_p xdut.xana.xsup.xvddreg.xcomp.xi25.intern c=1.68278e-15
c5_716 xdut.gnd_p xdut.xana.xsup.xvddreg.vdd_uv_i c=3.24369e-15
c5_710 xdut.gnd_p xdut.xana.xsup.xvddreg.xi37.p0 c=1.76128e-15
c5_709 xdut.gnd_p xdut.xana.xsup.xvddreg.xcomp.nn2 c=3.47421e-15
c5_708 xdut.gnd_p xdut.xana.xsup.xvddreg.xcomp.nn1 c=1.8009e-15
c5_707 xdut.gnd_p xdut.xana.xsup.xvddreg.xcomp.nn3 c=4.82801e-15
c5_706 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<31> c=7.84675e-15
c5_705 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<28> c=6.29084e-15
c5_704 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv<33> c=3.06299e-15
c5_703 xdut.gnd_p xdut.xana.xsup.xvddreg.vbg_int c=6.19223e-14
c5_702 xdut.gnd_p xdut.xana.xsup.xvddreg.rdiv_en c=2.60083e-15
c5_700 xdut.gnd_p xdut.xana.xsup.xvddreg.net153 c=1.69299e-14
c5_699 xdut.gnd_p xdut.xana.xsup.xvddreg.iload_en c=3.3325e-15
c5_662 xdut.gnd_p xdut.xana.xsup.xvccreg.xreg.gate c=4.6045e-15
c5_659 xdut.gnd_p xdut.xana.xsup.xvccreg.xreg.net1204 c=1.47004e-15
c5_657 xdut.gnd_p xdut.xana.xsup.xvccreg.xreg.net1078 c=1.29673e-14
c5_656 xdut.gnd_p xdut.xana.xsup.xvccreg.xreg.err_amp_base c=6.61497e-14
c5_655 xdut.gnd_p xdut.xana.xsup.xvccreg.xreg.net878 c=1.49421e-15
c5_654 xdut.gnd_p xdut.xana.xsup.xvccreg.xreg.gain_i c=9.11724e-15
c5_653 xdut.gnd_p xdut.xana.xsup.xvccreg.xreg.net1191 c=1.97267e-15
c5_652 xdut.gnd_p xdut.xana.xsup.xvccreg.xreg.startup_int c=1.42436e-14
c5_651 xdut.gnd_p xdut.xana.xsup.xvccreg.xreg.vglim c=5.77353e-15
c5_650 xdut.gnd_p xdut.xana.xsup.xvccreg.xreg.net1176 c=3.37773e-15
c5_647 xdut.gnd_p xdut.xana.xsup.xvccreg.xreg.n0 c=1.46259e-14
c5_646 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<9> c=1.39474e-15
c5_645 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<99> c=2.5961e-15
c5_644 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<98> c=1.47622e-15
c5_643 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<97> c=1.53196e-15
c5_642 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<96> c=1.45114e-15
c5_641 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<95> c=1.54692e-15
c5_640 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<94> c=1.45786e-15
c5_639 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<93> c=1.53859e-15
c5_638 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<92> c=1.46627e-15
c5_637 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<91> c=1.54527e-15
c5_636 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<90> c=1.46059e-15
c5_635 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<8> c=2.05209e-15
c5_634 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<89> c=1.53247e-15
c5_633 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<88> c=1.4648e-15
c5_632 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<87> c=1.53872e-15
c5_631 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<86> c=1.44328e-15
c5_630 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<85> c=1.5412e-15
c5_629 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<84> c=1.45991e-15
c5_628 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<83> c=1.53993e-15
c5_627 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<82> c=1.44342e-15
c5_626 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<81> c=1.52975e-15
c5_625 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<80> c=1.46611e-15
c5_624 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<7> c=1.41819e-15
c5_623 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<79> c=1.53284e-15
c5_622 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<78> c=1.45342e-15
c5_621 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<77> c=1.53115e-15
c5_620 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<76> c=1.45544e-15
c5_619 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<75> c=1.55825e-15
c5_618 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<74> c=1.4628e-15
c5_617 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<73> c=1.53647e-15
c5_616 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<72> c=1.44181e-15
c5_615 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<71> c=1.53595e-15
c5_614 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<70> c=1.45253e-15
c5_613 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<6> c=2.04523e-15
c5_612 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<69> c=1.53269e-15
c5_611 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<68> c=1.44609e-15
c5_610 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<67> c=1.5498e-15
c5_609 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<66> c=1.43961e-15
c5_608 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<65> c=1.54469e-15
c5_607 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<64> c=1.47882e-15
c5_606 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<63> c=1.54184e-15
c5_605 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<62> c=1.48069e-15
c5_604 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<61> c=1.53596e-15
c5_603 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<60> c=1.48292e-15
c5_602 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<5> c=1.39837e-15
c5_601 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<59> c=1.54037e-15
c5_600 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<58> c=1.47833e-15
c5_599 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<57> c=1.57944e-15
c5_598 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<56> c=1.47176e-15
c5_597 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<55> c=1.56128e-15
c5_596 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<54> c=1.46856e-15
c5_595 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<53> c=1.56359e-15
c5_594 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<51> c=1.58002e-15
c5_593 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<50> c=1.67965e-15
c5_592 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<4> c=2.04464e-15
c5_591 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<49> c=1.42762e-15
c5_590 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<48> c=2.09244e-15
c5_589 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<47> c=1.42932e-15
c5_588 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<46> c=2.04763e-15
c5_587 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<45> c=1.42651e-15
c5_586 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<44> c=2.05635e-15
c5_585 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<43> c=1.43891e-15
c5_584 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<42> c=2.06053e-15
c5_583 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<41> c=1.39759e-15
c5_582 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<40> c=2.07913e-15
c5_581 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<3> c=1.39556e-15
c5_580 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<39> c=1.40346e-15
c5_579 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<38> c=2.07373e-15
c5_578 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<37> c=1.39836e-15
c5_577 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<36> c=2.08601e-15
c5_576 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<34> c=2.04752e-15
c5_575 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<33> c=1.41929e-15
c5_574 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<32> c=2.0299e-15
c5_573 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<31> c=1.39931e-15
c5_572 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<30> c=2.02277e-15
c5_571 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<2> c=2.29324e-15
c5_570 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<27> c=1.39389e-15
c5_569 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<26> c=2.05819e-15
c5_568 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<24> c=2.03726e-15
c5_567 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<23> c=1.39836e-15
c5_566 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<22> c=2.04305e-15
c5_565 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<21> c=1.4024e-15
c5_564 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<20> c=2.04167e-15
c5_563 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<1> c=2.58092e-15
c5_562 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<19> c=1.39948e-15
c5_561 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<18> c=2.03912e-15
c5_560 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<17> c=1.38971e-15
c5_559 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<16> c=2.04705e-15
c5_558 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<15> c=1.40535e-15
c5_557 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<14> c=2.04004e-15
c5_556 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<13> c=1.40254e-15
c5_555 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<12> c=2.04617e-15
c5_554 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<11> c=1.39789e-15
c5_553 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<10> c=2.04176e-15
c5_552 xdut.gnd_p xdut.xana.xsup.xvccreg.xrdiv_vdda.net113 c=1.68088e-15
c5_551 xdut.gnd_p xdut.xana.xsup.xvrrmon.xrdiv.net132 c=1.40349e-15
c5_547 xdut.gnd_p xdut.xana.xsup.vcc_uv_5v c=2.67334e-15
c5_546 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<52> c=1.47131e-15
c5_545 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<35> c=1.39548e-15
c5_542 xdut.gnd_p xdut.xana.xsup.xvccreg.divh c=1.19101e-15
c5_540 xdut.gnd_p xdut.xana.xsup.xvccreg.divl c=1.17017e-15
c5_539 xdut.gnd_p xdut.xana.xsup.xvccreg.xcomp.enb c=1.86921e-15
c5_538 xdut.gnd_p xdut.xana.xsup.xvccreg.xcomp.net60 c=2.12344e-15
c5_535 xdut.gnd_p xdut.xana.xsup.xvccreg.xcomp.nn4 c=1.33613e-15
c5_534 xdut.gnd_p xdut.xana.xsup.xvccreg.xcomp.nn6 c=5.66746e-15
c5_532 xdut.gnd_p xdut.xana.xsup.xvccreg.xcomp.nnvc c=8.43513e-14
c5_530 xdut.gnd_p xdut.xana.xsup.xvccreg.xcomp.nn3 c=4.74916e-15
c5_529 xdut.gnd_p xdut.xana.xsup.xvccreg.xcomp.nn1 c=1.92016e-15
c5_528 xdut.gnd_p xdut.xana.xsup.xvccreg.xcomp.xi25.intern c=1.66612e-15
c5_527 xdut.gnd_p xdut.xana.xsup.xvccreg.xcomp.nn2 c=3.5123e-15
c5_524 xdut.gnd_p xdut.xana.xsup.xvddreg.xvddreg.nbl1 c=5.53798e-14
c5_523 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<28> c=3.50504e-15
c5_522 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<25> c=4.31372e-15
c5_521 xdut.gnd_p xdut.xana.xsup.xvccreg.rdiv<29> c=5.34819e-15
c5_518 xdut.gnd_p xdut.xana.xsup.xvccreg.vbg_int c=4.76364e-13
c5_516 xdut.gnd_p xdut.xana.xsup.xvbgbuf.net213 c=2.4055e-14
c5_515 xdut.gnd_p xdut.xana.xsup.xvbgbuf.vg_m5 c=1.0992e-13
c5_514 xdut.gnd_p xdut.xana.xsup.xvbgbuf.vgpc c=1.15281e-14
c5_513 xdut.gnd_p xdut.xana.xsup.xvbgbuf.net163 c=7.69389e-15
c5_512 xdut.gnd_p xdut.xana.xsup.xvbgbuf.vgp c=1.02467e-14
c5_511 xdut.gnd_p xdut.xana.xsup.xref.xiconst.z c=1.3004e-14
c5_510 xdut.gnd_p xdut.xana.xsup.xref.xiconst.xop.net15 c=3.30641e-15
c5_509 xdut.gnd_p xdut.xana.xsup.xref.xiconst.xop.net12 c=4.27989e-15
c5_508 xdut.gnd_p xdut.xana.xsup.xref.xiconst.xop.vcasn c=9.189e-15
c5_506 xdut.gnd_p xdut.xana.xsup.xref.xiconst.xop.vbp c=1.62255e-15
c5_505 xdut.gnd_p xdut.xana.xsup.xref.xiconst.xop.vcasp c=1.8095e-15
c5_504 xdut.gnd_p xdut.xana.xsup.xref.xiconst.xop.vbn_amp c=1.41587e-14
c5_498 xdut.gnd_p xdut.xana.xsup.xref.xiconst.xcm2.vcasp c=1.23685e-15
c5_496 xdut.gnd_p xdut.xana.xsup.xref.xiconst.xcm2.vbn c=1.05471e-14
c5_491 xdut.gnd_p xdut.xana.xsup.xref.xiconst.xcm1.vcasp c=2.22195e-15
c5_490 xdut.gnd_p xdut.xana.xsup.xref.xiconst.xcm1.vbn c=7.15874e-15
c5_489 xdut.gnd_p xdut.xana.xsup.xref.xiconst.net234 c=1.57477e-14
c5_488 xdut.gnd_p xdut.xana.xsup.xref.xiconst.net226 c=2.05232e-14
c5_487 xdut.gnd_p xdut.xana.xsup.xref.xiconst.vbn c=7.49964e-14
c5_486 xdut.gnd_p xdut.xana.ln_sup.ref.iconst.n_603 c=1.86473e-15
c5_485 xdut.gnd_p xdut.xana.ln_sup.ref.iconst.n_602 c=2.08583e-15
c5_484 xdut.gnd_p xdut.xana.ln_sup.ref.iconst.n_601 c=1.93017e-15
c5_483 xdut.gnd_p xdut.xana.ln_sup.ref.iconst.n_600 c=1.93708e-15
c5_482 xdut.gnd_p xdut.xana.ln_sup.ref.iconst.n_599 c=1.96382e-15
c5_481 xdut.gnd_p xdut.xana.ln_sup.ref.iconst.n_598 c=1.89347e-15
c5_480 xdut.gnd_p xdut.xana.ln_sup.ref.iconst.n_597 c=1.89619e-15
c5_479 xdut.gnd_p xdut.xana.ln_sup.ref.iconst.n_596 c=1.96428e-15
c5_478 xdut.gnd_p xdut.xana.ln_sup.ref.iconst.n_595 c=1.89376e-15
c5_477 xdut.gnd_p xdut.xana.ln_sup.ref.iconst.n_594 c=1.91852e-15
c5_476 xdut.gnd_p xdut.xana.ln_sup.ref.iconst.n_593 c=1.92824e-15
c5_475 xdut.gnd_p xdut.xana.ln_sup.ref.iconst.n_592 c=1.89745e-15
c5_474 xdut.gnd_p xdut.xana.ln_sup.ref.iconst.n_591 c=2.01674e-15
c5_473 xdut.gnd_p xdut.xana.ln_sup.ref.iconst.n_590 c=3.6704e-15
c5_472 xdut.gnd_p xdut.xana.xsup.xref.xiconst.a2 c=9.1894e-15
c5_471 xdut.gnd_p xdut.xana.xsup.xref.xiconst.net251 c=3.78948e-15
c5_470 xdut.gnd_p xdut.xana.xsup.xref.xiconst.net258 c=4.32201e-15
c5_469 xdut.gnd_p xdut.xana.xsup.xref.xiconst.ic9u<3> c=7.67092e-15
c5_468 xdut.gnd_p xdut.xana.xsup.xref.xiconst.ic9u<2> c=6.71418e-15
c5_467 xdut.gnd_p xdut.xana.xsup.xref.xiconst.ic9u<1> c=1.22739e-15
c5_466 xdut.gnd_p xdut.xana.xsup.xref.xiconst.ic9u<0> c=3.24152e-15
c5_465 xdut.gnd_p xdut.xana.xsup.xref.xiconst.irpo5u c=1.4167e-14
c5_464 xdut.gnd_p xdut.xana.xsup.xref.xiconst.a1 c=1.4757e-14
c5_463 xdut.gnd_p xdut.xana.xsup.xref.xiconst.tr3n c=4.0601e-15
c5_462 xdut.gnd_p xdut.xana.xsup.xref.xiconst.gate c=8.49863e-15
c5_460 xdut.gnd_p xdut.xana.xsup.xref.xiconst.tr0 c=3.46918e-15
c5_459 xdut.gnd_p xdut.xana.xsup.xref.xiconst.xi46.net6 c=1.03698e-15
c5_458 xdut.gnd_p xdut.xana.xsup.xref.xiconst.tr1 c=2.3453e-15
c5_457 xdut.gnd_p xdut.xana.xsup.xref.xiconst.xi45.net6 c=1.02758e-15
c5_456 xdut.gnd_p xdut.xana.xsup.xref.xiconst.vbuf c=8.78412e-15
c5_455 xdut.gnd_p xdut.xana.xsup.xref.xiconst.tr2 c=3.25277e-15
c5_454 xdut.gnd_p xdut.xana.xsup.xref.xiconst.net252 c=7.6982e-15
c5_453 xdut.gnd_p xdut.xana.xsup.xref.xiconst.net259 c=8.0987e-15
c5_452 xdut.gnd_p xdut.xana.xsup.xref.xiconst.net274 c=2.35733e-14
c5_451 xdut.gnd_p xdut.xana.xsup.xref.xiconst.net233 c=4.14601e-15
c5_450 xdut.gnd_p xdut.xana.xsup.xref.xiconst.net244 c=4.16128e-15
c5_449 xdut.gnd_p xdut.xana.xsup.xref.xiconst.net245 c=8.26718e-15
c5_436 xdut.gnd_p xdut.xana.xsup.xref.xbg.net440 c=5.97484e-15
c5_435 xdut.gnd_p xdut.xana.xsup.xref.xbg.net539 c=3.34799e-15
c5_434 xdut.gnd_p xdut.xana.xsup.xref.xbg.net532 c=1.72963e-14
c5_433 xdut.gnd_p xdut.xana.xsup.xref.xbg.b c=7.08541e-14
c5_432 xdut.gnd_p xdut.xana.xsup.xref.xbg.vbp_ibias c=3.88978e-15
c5_431 xdut.gnd_p xdut.xana.xsup.xref.xbg.nwell1 c=9.94484e-13
c5_430 xdut.gnd_p xdut.xana.xsup.xref.xbg.net453 c=5.04378e-15
c5_429 xdut.gnd_p xdut.xana.xsup.xref.xbg.net427 c=3.29725e-15
c5_428 xdut.gnd_p xdut.xana.xsup.xref.xbg.a c=5.85919e-14
c5_427 xdut.gnd_p xdut.xana.xsup.xref.xbg.net497 c=5.3029e-14
c5_426 xdut.gnd_p xdut.xana.xsup.xref.xbg.net496 c=2.01098e-13
c5_425 xdut.gnd_p xdut.xana.xsup.xref.xbg.rs_nwell c=4.0782e-14
c5_424 xdut.gnd_p xdut.xana.xsup.ibp10u<0> c=3.10898e-15
c5_423 xdut.gnd_p xdut.xana.xsup.xref.ibp1u<3> c=6.39677e-14
c5_422 xdut.gnd_p xdut.xana.xsup.xref.ibp1u<2> c=6.32155e-14
c5_421 xdut.gnd_p xdut.xana.xsup.xref.ibp1u<1> c=6.1658e-14
c5_420 xdut.gnd_p xdut.xana.xsup.xref.ibp1u<0> c=7.70278e-14
c5_419 xdut.gnd_p xdut.xana.xsup.xref.vref_iconst c=1.02629e-14
c5_411 xdut.gnd_p xdut.xana.xsup.xmux.xsw1.net28 c=1.91242e-15
c5_410 xdut.gnd_p xdut.xana.xsup.xmux.xsw2.net28 c=1.92058e-15
c5_409 xdut.gnd_p xdut.xana.xsup.xmux.vbg_int c=2.89265e-15
c5_408 xdut.gnd_p xdut.xana.xsup.xmux.xsw2.en_int c=1.61837e-15
c5_407 xdut.gnd_p xdut.xana.xsup.xmux.xsw2.enb_int c=1.58985e-15
c5_406 xdut.gnd_p xdut.xana.xsup.xmux.xsw3.en_int c=1.61505e-15
c5_405 xdut.gnd_p xdut.xana.xsup.xmux.xsw3.enb_int c=1.61657e-15
c5_404 xdut.gnd_p xdut.xana.xsup.xmux.xsw4.en_int c=1.63465e-15
c5_403 xdut.gnd_p xdut.xana.xsup.xmux.xsw4.enb_int c=1.61271e-15
c5_402 xdut.gnd_p xdut.xana.xsup.xmux.xsw1.en_int c=1.6068e-15
c5_401 xdut.gnd_p xdut.xana.xsup.xmux.xsw1.enb_int c=1.64013e-15
c5_400 xdut.gnd_p xdut.xana.xsup.xmux.xsw3.net28 c=1.91414e-15
c5_399 xdut.gnd_p xdut.xana.xsup.xmux.xsw4.net28 c=1.91693e-15
c5_397 xdut.gnd_p xdut.xana.xsup.xls3<3>.xd2a_hvpart_inst.net038 c=1.35543e-15
c5_396 xdut.gnd_p xdut.xana.xsup.xls3<4>.xd2a_hvpart_inst.net038 c=1.35703e-15
c5_394 xdut.gnd_p xdut.xana.xsup.atst_sup_5v<4> c=4.19994e-15
c5_393 xdut.gnd_p xdut.xana.xotpmux.xls<3>.pull_up c=1.0461e-15
c5_390 xdut.gnd_p xdut.xana.xsup.xls7<0>.xd2a_hvpart_inst.net038 c=1.35424e-15
c5_388 xdut.gnd_p xdut.xana.xsup.i_trim_5v<0> c=3.34962e-15
c5_387 xdut.gnd_p xdut.xana.xsup.i_trim_5v<1> c=2.27402e-15
c5_386 xdut.gnd_p xdut.xana.xotpmux.xls<4>.pull_up c=1.04618e-15
c5_383 xdut.gnd_p xdut.xana.xotpmux.xls<5>.pull_up c=1.04616e-15
c5_382 xdut.gnd_p xdut.xana.xsup.xls7<1>.xd2a_hvpart_inst.net038 c=1.35287e-15
c5_381 xdut.gnd_p xdut.xana.xsup.ibp10u<3> c=5.79019e-15
c5_380 xdut.gnd_p xdut.xana.xsup.xref.iaux10u c=1.21838e-14
c5_378 xdut.gnd_p xdut.xana.xsup.i_trim_5v<2> c=2.29207e-15
c5_377 xdut.gnd_p xdut.xana.xsup.ibp5u<1> c=1.82079e-14
c5_374 xdut.gnd_p xdut.xana.xsup.ic5u<12> c=2.87078e-14
c5_373 xdut.gnd_p xdut.xana.xtmon.xls4<0>.pull_up c=1.046e-15
c5_370 xdut.gnd_p xdut.xana.xsup.xls7<2>.xd2a_hvpart_inst.net038 c=1.35416e-15
c5_367 xdut.gnd_p xdut.xana.xsup.i_trim_5v<3> c=3.15866e-15
c5_366 xdut.gnd_p xdut.xana.xsup.xvrrmon.vrr_uv_5v c=1.68027e-15
c5_365 xdut.gnd_p xdut.xana.xsup.xvrrmon.vrr_ov_5v c=3.04604e-15
c5_364 xdut.gnd_p xdut.xana.xsup.xvbgbuf.vcc_nbl c=3.58515e-14
c5_363 xdut.gnd_p xdut.xana.xsup.xls7<3>.xd2a_hvpart_inst.net038 c=1.38078e-15
c5_361 xdut.gnd_p xdut.xana.xsup.xvrrmon.net9 c=1.23943e-14
c5_360 xdut.gnd_p xdut.xana.xsup.xvrrmon.net5 c=2.84342e-15
c5_359 xdut.gnd_p xdut.xana.xsup.ibp10u<1> c=2.25794e-14
c5_357 xdut.gnd_p xdut.xana.xsup.xvrrmon.net42 c=1.98538e-15
c5_338 xdut.gnd_p xdut.xana.xldo.xls1.pull_up c=1.065e-15
c5_335 xdut.gnd_p xdut.xana.xsup.xls3<0>.xd2a_hvpart_inst.net038 c=1.3511e-15
c5_333 xdut.gnd_p xdut.xana.xsup.atst_sup_5v<0> c=8.37406e-15
c5_332 xdut.gnd_p xdut.xana.xsup.atst_sup_5v<1> c=4.35696e-15
c5_331 xdut.gnd_p xdut.xana.xldo.xls2.pull_up c=1.04534e-15
c5_328 xdut.gnd_p xdut.xana.xotpmux.xls<0>.pull_up c=1.04626e-15
c5_327 xdut.gnd_p xdut.xana.xsup.xls3<1>.xd2a_hvpart_inst.net038 c=1.35724e-15
c5_325 xdut.gnd_p xdut.xana.xsup.atst_sup_5v<2> c=4.55884e-15
c5_322 xdut.gnd_p xdut.xana.xotpmux.xls<1>.pull_up c=1.04649e-15
c5_319 xdut.gnd_p xdut.xana.xsup.xls3<2>.xd2a_hvpart_inst.net038 c=1.35328e-15
c5_316 xdut.gnd_p xdut.xana.xsup.atst_sup_5v<3> c=7.83593e-15
c5_315 xdut.gnd_p xdut.xana.xotpmux.xls<2>.pull_up c=1.04441e-15
c5_313 xdut.gnd_p xdut.xana.irp10u<3> c=1.25655e-14
c5_312 xdut.gnd_p xdut.xana.irp10u<2> c=1.14267e-14
c5_311 xdut.gnd_p xdut.xana.ic5u<7> c=8.25317e-15
c5_310 xdut.gnd_p xdut.xana.ic5u<2> c=7.32472e-15
c5_309 xdut.gnd_p xdut.xana.ic5u<3> c=2.50506e-14
c5_308 xdut.gnd_p xdut.xana.ic5u<6> c=2.3494e-14
c5_300 xdut.gnd_p xdut.xana.xotpmux.vpp_div c=9.55938e-15
c5_299 xdut.gnd_p xdut.xana.xotpmux.xsw3.net28 c=2.09866e-15
c5_298 xdut.gnd_p xdut.xana.xotpmux.xsw3.en_int c=1.66033e-15
c5_297 xdut.gnd_p xdut.xana.xotpmux.xsw3.enb_int c=1.74236e-15
c5_296 xdut.gnd_p xdut.xana.xsup.xls7<1>.pull_up c=1.13719e-15
c5_293 xdut.gnd_p xdut.xana.xotpmux.net368 c=1.61301e-15
c5_292 xdut.gnd_p xdut.xana.xotpmux.xls<5>.xd2a_hvpart_inst.net038 c=1.37243e-15
c5_290 xdut.gnd_p xdut.xana.xotpmux.atst_otp_5v<5> c=1.34142e-15
c5_287 xdut.gnd_p xdut.xana.xsup.xls7<2>.pull_up c=1.11738e-15
c5_284 xdut.gnd_p xdut.xana.xotpmux.xls<1>.xd2a_hvpart_inst.net038 c=1.36772e-15
c5_282 xdut.gnd_p xdut.xana.xotpmux.xls<0>.xd2a_hvpart_inst.net038 c=1.36863e-15
c5_280 xdut.gnd_p xdut.xana.xotpmux.atst_otp_5v<0> c=1.17779e-14
c5_279 xdut.gnd_p xdut.xana.xtmon.xls4<1>.pull_up c=1.11351e-15
c5_278 xdut.gnd_p xdut.xana.xtmon.xls1<0>.pull_up c=1.11723e-15
c5_275 xdut.gnd_p xdut.xana.xotpmux.atst_otp_5v<1> c=4.34466e-15
c5_273 xdut.gnd_p xdut.xana.xotpmux.atst_otp_5v<2> c=5.4652e-15
c5_272 xdut.gnd_p xdut.xana.xsup.xls7<0>.pull_up c=1.11659e-15
c5_270 xdut.gnd_p xdut.xana.xotpmux.net285 c=1.04399e-14
c5_269 xdut.gnd_p xdut.xana.xotpmux.net277 c=7.05953e-15
c5_268 xdut.gnd_p xdut.xana.xotpmux.net281 c=6.99105e-15
c5_267 xdut.gnd_p xdut.xana.xotpmux.net273 c=7.11363e-15
c5_266 xdut.gnd_p xdut.xana.xotpmux.net275 c=7.01735e-15
c5_265 xdut.gnd_p xdut.xana.xotpmux.net279 c=7.03632e-15
c5_263 xdut.gnd_p xdut.xana.xotpmux.xls<2>.xd2a_hvpart_inst.net038 c=1.37208e-15
c5_262 xdut.gnd_p xdut.xana.xotpmux.xls<3>.xd2a_hvpart_inst.net038 c=1.36443e-15
c5_260 xdut.gnd_p xdut.xana.xotpmux.vbn1 c=2.76449e-14
c5_259 xdut.gnd_p xdut.xana.xotpmux.atst_otp_5v<3> c=1.0452e-14
c5_258 xdut.gnd_p xdut.xana.xtmon.xls1<1>.pull_up c=1.12095e-15
c5_256 xdut.gnd_p xdut.xana.xotpmux.vbn c=7.67853e-14
c5_254 xdut.gnd_p xdut.xana.xotpmux.xls<4>.xd2a_hvpart_inst.net038 c=1.3871e-15
c5_252 xdut.gnd_p xdut.xana.xotpmux.dm1 c=7.79915e-14
c5_251 xdut.gnd_p xdut.xana.xotpmux.atst_otp_5v<4> c=2.85501e-15
c5_250 xdut.gnd_p xdut.xana.xotpmux.dm11 c=6.01181e-14
c5_249 xdut.gnd_p xdut.xana.xotpmux.net372 c=2.78399e-15
c5_236 xdut.gnd_p xdut.xana.xotpmux.xsw0.en_int c=1.64993e-15
c5_235 xdut.gnd_p xdut.xana.xotpmux.xsw0.enb_int c=1.95193e-15
c5_234 xdut.gnd_p xdut.xana.xotpmux.vbg_int c=3.50586e-15
c5_233 xdut.gnd_p xdut.xana.xotpmux.xsw0.net28 c=2.09528e-15
c5_232 xdut.gnd_p xdut.xana.xotpmux.xsw1.enb_int c=1.72588e-15
c5_231 xdut.gnd_p xdut.xana.xotpmux.xsw1.net28 c=2.08447e-15
c5_230 xdut.gnd_p xdut.xana.xotpmux.xsw1.en_int c=1.65598e-15
c5_229 xdut.gnd_p xdut.xana.xotpmux.xsw2.en_int c=1.64817e-15
c5_228 xdut.gnd_p xdut.xana.xotpmux.xsw2.enb_int c=1.73042e-15
c5_227 xdut.gnd_p xdut.xana.xotpmux.xsw2.net28 c=2.0766e-15
c5_223 xdut.gnd_p xdut.xana.xldo.xvref.sel_0 c=1.10336e-15
c5_220 xdut.gnd_p xdut.xana.xldo.xvref.net30 c=5.79814e-15
c5_218 xdut.gnd_p xdut.xana.xldo.xvref.net34 c=6.92003e-15
c5_216 xdut.gnd_p xdut.xana.xldo.xvref.net38 c=6.27071e-15
c5_214 xdut.gnd_p xdut.xana.xldo.xvref.net42 c=8.50168e-15
c5_212 xdut.gnd_p xdut.xana.xldo.xvref.net46 c=7.23207e-15
c5_210 xdut.gnd_p xdut.xana.xldo.xvref.net50 c=1.45215e-14
c5_208 xdut.gnd_p xdut.xana.xldo.xvref.net211 c=1.14022e-14
c5_206 xdut.gnd_p xdut.xana.ln_ldo.vref.n_226 c=4.94488e-15
c5_205 xdut.gnd_p xdut.xana.xldo.xvref.net212 c=1.03162e-14
c5_204 xdut.gnd_p xdut.xana.ln_ldo.vref.n_223 c=4.95288e-15
c5_203 xdut.gnd_p xdut.xana.ln_ldo.vref.n_222 c=5.01679e-15
c5_202 xdut.gnd_p xdut.xana.ln_ldo.vref.n_221 c=4.86322e-15
c5_201 xdut.gnd_p xdut.xana.ln_ldo.vref.n_220 c=4.9588e-15
c5_200 xdut.gnd_p xdut.xana.ln_ldo.vref.n_219 c=5.00626e-15
c5_199 xdut.gnd_p xdut.xana.ln_ldo.vref.n_218 c=1.05821e-14
c5_198 xdut.gnd_p xdut.xana.xldo.xvref.bit<2> c=4.89084e-15
c5_197 xdut.gnd_p xdut.xana.xldo.xvref.bit<1> c=3.16432e-15
c5_196 xdut.gnd_p xdut.xana.xldo.xvref.bit<0> c=2.92666e-15
c5_179 xdut.gnd_p xdut.xana.xldo.xvref.b2n c=2.58332e-15
c5_178 xdut.gnd_p xdut.xana.xldo.xvref.b1n c=2.54046e-15
c5_177 xdut.gnd_p xdut.xana.xldo.xvref.b0n c=4.81327e-15
c5_164 xdut.gnd_p xdut.xana.xldo.xuvcomp.nn1 c=1.89379e-15
c5_160 xdut.gnd_p xdut.xana.xldo.s_cas2 c=3.23915e-15
c5_159 xdut.gnd_p xdut.xana.xldo.s_cas1 c=1.01724e-15
c5_158 xdut.gnd_p xdut.xana.xldo.net636 c=1.0431e-14
c5_156 xdut.gnd_p xdut.xana.xldo.vd_msen c=4.03257e-15
c5_155 xdut.gnd_p xdut.xana.ln_ldo.n_464 c=5.0494e-15
c5_154 xdut.gnd_p xdut.xana.ln_ldo.n_463 c=9.81018e-15
c5_153 xdut.gnd_p xdut.xana.ln_ldo.n_462 c=9.39147e-15
c5_152 xdut.gnd_p xdut.xana.ln_ldo.n_456 c=4.77456e-15
c5_151 xdut.gnd_p xdut.xana.ln_ldo.n_455 c=4.76812e-15
c5_150 xdut.gnd_p xdut.xana.ln_ldo.n_454 c=4.68484e-15
c5_149 xdut.gnd_p xdut.xana.ln_ldo.n_449 c=4.86309e-15
c5_148 xdut.gnd_p xdut.xana.xldo.vdiv2 c=1.67742e-14
c5_147 xdut.gnd_p xdut.xana.ln_ldo.n_447 c=4.89336e-15
c5_146 xdut.gnd_p xdut.xana.ln_ldo.n_445 c=4.77664e-15
c5_145 xdut.gnd_p xdut.xana.ln_ldo.n_444 c=4.775e-15
c5_144 xdut.gnd_p xdut.xana.ln_ldo.n_443 c=4.77654e-15
c5_143 xdut.gnd_p xdut.xana.ln_ldo.n_442 c=9.67879e-15
c5_142 xdut.gnd_p xdut.xana.ln_ldo.n_441 c=4.8581e-15
c5_141 xdut.gnd_p xdut.xana.ln_ldo.n_440 c=4.86275e-15
c5_140 xdut.gnd_p xdut.xana.ln_ldo.n_439 c=4.87248e-15
c5_139 xdut.gnd_p xdut.xana.ln_ldo.n_438 c=4.86375e-15
c5_138 xdut.gnd_p xdut.xana.xldo.xsw_atb.en_int c=1.64087e-15
c5_137 xdut.gnd_p xdut.xana.xldo.xsw_atb.enb_int c=1.66952e-15
c5_136 xdut.gnd_p xdut.xana.xldo.xsw_atb.net28 c=1.94545e-15
c5_131 xdut.gnd_p xdut.xana.xldo.dm2 c=4.72283e-15
c5_127 xdut.gnd_p xdut.xana.xldo.xuvcomp.xi25.intern c=1.70858e-15
c5_125 xdut.gnd_p xdut.xana.xldo.xamp.ena c=2.18149e-15
c5_124 xdut.gnd_p xdut.xana.xldo.xuvcomp.net60 c=2.11556e-15
c5_123 xdut.gnd_p xdut.xana.xldo.xamp.dis_int c=1.26753e-15
c5_122 xdut.gnd_p xdut.xana.xldo.i5u_ota c=7.68609e-15
c5_121 xdut.gnd_p xdut.xana.xldo.xamp.vpb c=1.25523e-15
c5_120 xdut.gnd_p xdut.xana.xldo.xamp.cmg c=8.19255e-15
c5_119 xdut.gnd_p xdut.xana.xldo.xamp.gl c=6.18282e-15
c5_118 xdut.gnd_p xdut.xana.xldo.xamp.glm c=2.56571e-15
c5_117 xdut.gnd_p xdut.xana.xldo.ota_out c=2.0306e-13
c5_116 xdut.gnd_p xdut.xana.xldo.xamp.gr c=5.97697e-15
c5_114 xdut.gnd_p xdut.xana.xldo.xls2.ls_an c=1.23911e-15
c5_113 xdut.gnd_p xdut.xana.xldo.xls2.xd2a_hvpart_inst.net038 c=1.40684e-15
c5_111 xdut.gnd_p xdut.xana.xldo.vdsi_off_5v c=1.55514e-14
c5_109 xdut.gnd_p xdut.xana.xsup.xls7<3>.pull_up c=1.07447e-15
c5_106 xdut.gnd_p xdut.xana.xsup.xls3<0>.pull_up c=1.10161e-15
c5_105 xdut.gnd_p xdut.xana.xldo.xls1.xd2a_hvpart_inst.net038 c=1.37825e-15
c5_103 xdut.gnd_p xdut.xana.xldo.vdsi_on_5v c=1.80092e-15
c5_102 xdut.gnd_p xdut.xana.xldo.vdsi2atb_5v c=1.90554e-15
c5_101 xdut.gnd_p xdut.xana.ln_ldo.n_1022 c=2.6858e-15
c5_100 xdut.gnd_p xdut.xana.ln_ldo.n_1021 c=2.68899e-15
c5_99 xdut.gnd_p xdut.xana.ln_ldo.n_1020 c=2.68408e-15
c5_98 xdut.gnd_p xdut.xana.ln_ldo.n_1019 c=2.68388e-15
c5_97 xdut.gnd_p xdut.xana.ln_ldo.n_1018 c=2.69049e-15
c5_96 xdut.gnd_p xdut.xana.ln_ldo.n_1017 c=2.68921e-15
c5_95 xdut.gnd_p xdut.xana.ln_ldo.n_1016 c=2.68546e-15
c5_94 xdut.gnd_p xdut.xana.ln_ldo.n_1015 c=7.64718e-15
c5_93 xdut.gnd_p xdut.xana.ln_ldo.n_1014 c=3.87856e-15
c5_92 xdut.gnd_p xdut.xana.ln_ldo.n_1013 c=8.21313e-15
c5_60 xdut.gnd_p xdut.xana.xsup.vrr_ok_5v c=3.30377e-15
c5_59 xdut.gnd_p xdut.xana.ic5u<11> c=4.54103e-14
c5_56 xdut.gnd_p xdut.xana.net875 c=1.22212e-14
c5_54 xdut.gnd_p xdut.xana.xi66.pull_up c=1.08623e-15
c5_50 xdut.gnd_p xdut.xana.xi66.xd2a_hvpart_inst.net038 c=1.38186e-15
c5_43 xdut.gnd_p xdut.trim_dsi_rx2<4> c=1.60995e-15
c5_42 xdut.gnd_p xdut.trim_dsi_rx2<5> c=1.63451e-15
c5_41 xdut.gnd_p xdut.trim_dsi_rx2<6> c=1.5524e-15
c5_40 xdut.gnd_p xdut.trim_dsi_rx1<5> c=1.52833e-15
c5_39 xdut.gnd_p xdut.trim_dsi_rx1<4> c=1.53032e-15
c5_38 xdut.gnd_p xdut.trim_dsi_rx2<7> c=1.77045e-15
c5_37 xdut.gnd_p xdut.trim_dsi_rx1<6> c=1.95119e-15
c5_36 xdut.gnd_p xdut.dsi_rx_on<1> c=1.55838e-15
c5_35 xdut.gnd_p xdut.trim_dsi_rx1<7> c=1.52077e-15
c5_34 xdut.gnd_p xdut.atst_rx<1> c=2.3504e-15
c5_33 xdut.gnd_p xdut.dsi_rxd2<1> c=1.6262e-15
c5_32 xdut.gnd_p xdut.dsi_rx_filter_fast<1> c=1.92318e-15
c5_31 xdut.gnd_p xdut.dsi_rxd1<1> c=2.08621e-15
c5_30 xdut.gnd_p xdut.dsi_tx_tbit_cfg<3> c=1.59188e-15
c5_29 xdut.gnd_p xdut.atst_tx<13> c=1.46662e-15
c5_28 xdut.gnd_p xdut.dsi_ov<1> c=2.51651e-15
c5_27 xdut.gnd_p xdut.dsi_rx_txn<1> c=2.06373e-15
c5_26 xdut.gnd_p xdut.dsi_tx_data<9> c=1.25031e-15
c5_25 xdut.gnd_p xdut.dsi_tx_tbit_cfg<2> c=1.71085e-15
c5_24 xdut.gnd_p xdut.dsi_idac<7> c=3.24003e-15
c5_23 xdut.gnd_p xdut.dsi_idac<8> c=1.4494e-15
c5_22 xdut.gnd_p xdut.dsi_idac<5> c=1.70551e-15
c5_21 xdut.gnd_p xdut.dsi_idac<9> c=1.45655e-15
c5_20 xdut.gnd_p xdut.dsi_idac<6> c=1.54472e-15
c5_19 xdut.gnd_p xdut.dsi_icmp<1> c=1.66632e-15
c5_18 xdut.gnd_p xdut.dsi_tx_data<7> c=1.21339e-15
c5_17 xdut.gnd_p xdut.dsi_tx_data<8> c=1.14719e-15
c5_16 xdut.gnd_p xdut.dsi_tx_data<5> c=1.40988e-15
c5_15 xdut.gnd_p xdut.dsi_tx_data<6> c=1.29701e-15
c5_14 xdut.gnd_p xdut.xana.xldo.vs_m0 c=9.08021e-15
c5_13 xdut.gnd_p xdut.xana.xldo.vbp_lim c=4.87298e-15
c5_12 xdut.gnd_p xdut.xana.xsup.xvddreg.xvddreg.net339 c=2.01873e-15
c5_11 xdut.gnd_p xdut.xana.xsup.xvccreg.xreg.n2_net c=1.87772e-15
c5_10 xdut.gnd_p xdut.xana.xsup.xvccreg.xreg.n1_net c=1.67934e-15
c5_9 xdut.gnd_p xdut.xana.xsup.xvccreg.xreg.net830 c=3.27804e-15
c5_8 xdut.gnd_p xdut.xana.xsup.xvccreg.xreg.net851 c=1.98692e-15
c5_7 xdut.gnd_p xdut.xana.xsup.xvccreg.xreg.net818 c=1.68789e-15
c5_6 xdut.gnd_p xdut.xana.xsup.xvccreg.xreg.vbat c=1.22051e-15
c5_5 xdut.gnd_p xdut.xana.xldo.vdsi_nbl c=3.52527e-15
c5_4 xdut.gnd_p xdut.xpad6_gnd.net_0 c=6.94031e-14
c5_3 xdut.gnd_p xdut.xpad6_gnd.net_2 c=6.91364e-14
c5_2 xdut.gnd_p xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 c=4.87511e-11
c5_1 xdut.gnd_p xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=8.91147e-12
cg4_162 xdut.dgnd_p 0 c=1.43668e-12
c4_159 xdut.dgnd_p xdut.xpad24.gnesd c=8.22862e-14
c4_156 xdut.dgnd_p xdut.xpad23.gnesd c=8.22863e-14
c4_153 xdut.dgnd_p xdut.xpad22.gnesd c=8.22863e-14
c4_150 xdut.dgnd_p xdut.xpad21.gnesd c=8.23437e-14
c4_149 xdut.dgnd_p xdut.xpad19_vio.net021 c=1.02026e-14
c4_148 xdut.dgnd_p xdut.xpad19_vio.net_0 c=4.11678e-14
c4_145 xdut.dgnd_p xdut.xpad2.gnesd c=8.22076e-14
c4_144 xdut.dgnd_p xdut.xi74.net021 c=9.56734e-15
c4_143 xdut.dgnd_p xdut.xi74.net_0 c=3.40463e-14
c4_140 xdut.dgnd_p xdut.xpad18.gnesd c=8.23043e-14
c4_137 xdut.dgnd_p xdut.xpad17.gnesd c=8.23093e-14
c4_134 xdut.dgnd_p xdut.xpad16.gnesd c=8.23093e-14
c4_131 xdut.dgnd_p xdut.xpad15.gnesd c=8.23093e-14
c4_128 xdut.dgnd_p xdut.xpad14.gnesd c=8.23093e-14
c4_125 xdut.dgnd_p xdut.xpad13.gnesd c=8.23093e-14
c4_123 xdut.dgnd_p xdut.xi75.net021 c=9.5699e-15
c4_122 xdut.dgnd_p xdut.xi75.net_0 c=3.4042e-14
c4_121 xdut.dgnd_p xdut.xpad20_gndio.net24 c=9.56826e-15
c4_120 xdut.dgnd_p xdut.xpad20_gndio.net_1 c=3.40446e-14
c4_119 xdut.dgnd_p xdut.net2135 c=3.27928e-15
c4_117 xdut.dgnd_p xdut.xpad17.gnstrong c=1.86532e-14
c4_116 xdut.dgnd_p xdut.xpad17.gnweak c=1.09055e-14
c4_115 xdut.dgnd_p xdut.xpad17.gpstrong c=1.79109e-15
c4_114 xdut.dgnd_p xdut.xpad17.gpweak c=5.24364e-15
c4_108 xdut.dgnd_p xdut.xpad2.gnstrong c=1.86547e-14
c4_107 xdut.dgnd_p xdut.xpad2.gnweak c=1.09032e-14
c4_106 xdut.dgnd_p xdut.xpad2.gpstrong c=1.79668e-15
c4_105 xdut.dgnd_p xdut.xpad2.gpweak c=5.23789e-15
c4_103 xdut.dgnd_p xdut.net2134 c=3.28379e-15
c4_102 xdut.dgnd_p xdut.net2456 c=3.35482e-15
c4_99 xdut.dgnd_p xdut.net2138 c=3.29613e-15
c4_95 xdut.dgnd_p xdut.xpad1.gnstrong c=1.86549e-14
c4_94 xdut.dgnd_p xdut.xpad1.gpstrong c=1.79802e-15
c4_93 xdut.dgnd_p xdut.net2140 c=3.31772e-15
c4_91 xdut.dgnd_p xdut.net2130 c=3.26478e-15
c4_86 xdut.dgnd_p xdut.xpad21.gnstrong c=1.8656e-14
c4_85 xdut.dgnd_p xdut.xpad21.gnweak c=1.09422e-14
c4_84 xdut.dgnd_p xdut.xpad21.gpweak c=5.25658e-15
c4_83 xdut.dgnd_p xdut.xpad21.gpstrong c=1.79873e-15
c4_82 xdut.dgnd_p xdut.net2131 c=3.26481e-15
c4_77 xdut.dgnd_p xdut.xpad22.gnstrong c=1.86465e-14
c4_76 xdut.dgnd_p xdut.xpad22.gnweak c=1.09393e-14
c4_75 xdut.dgnd_p xdut.xpad22.gpweak c=5.25662e-15
c4_74 xdut.dgnd_p xdut.xpad22.gpstrong c=1.79873e-15
c4_73 xdut.dgnd_p xdut.net2132 c=3.26482e-15
c4_68 xdut.dgnd_p xdut.xpad23.gnstrong c=1.86465e-14
c4_67 xdut.dgnd_p xdut.xpad23.gnweak c=1.09395e-14
c4_66 xdut.dgnd_p xdut.xpad23.gpweak c=5.25667e-15
c4_65 xdut.dgnd_p xdut.xpad23.gpstrong c=1.79873e-15
c4_64 xdut.dgnd_p xdut.net3230 c=3.26478e-15
c4_59 xdut.dgnd_p xdut.xpad24.gnstrong c=1.86464e-14
c4_58 xdut.dgnd_p xdut.xpad24.gnweak c=1.09396e-14
c4_57 xdut.dgnd_p xdut.xpad24.gpstrong c=1.79873e-15
c4_56 xdut.dgnd_p xdut.xpad24.gpweak c=5.25672e-15
c4_54 xdut.dgnd_p xdut.xi75.net_2 c=5.48656e-14
c4_52 xdut.dgnd_p xdut.xpad20_gndio.net_2 c=5.48891e-14
c4_51 xdut.dgnd_p xdut.xi74.net_2 c=5.49276e-14
c4_48 xdut.dgnd_p xdut.xpad19_vio.net_2 c=6.91925e-14
c4_47 xdut.dgnd_p xdut.net3138 c=3.31393e-15
c4_46 xdut.dgnd_p xdut.xpad13.gnstrong c=1.8653e-14
c4_45 xdut.dgnd_p xdut.xpad13.gpstrong c=1.78921e-15
c4_44 xdut.dgnd_p xdut.xpad13.gpweak c=5.25238e-15
c4_42 xdut.dgnd_p xdut.xpad13.gnweak c=1.09046e-14
c4_38 xdut.dgnd_p xdut.xpad14.gnstrong c=1.86531e-14
c4_37 xdut.dgnd_p xdut.xpad14.gnweak c=1.09177e-14
c4_36 xdut.dgnd_p xdut.xpad14.gpstrong c=1.79104e-15
c4_35 xdut.dgnd_p xdut.xpad14.gpweak c=5.23986e-15
c4_30 xdut.dgnd_p xdut.net2136 c=3.28912e-15
c4_29 xdut.dgnd_p xdut.xpad15.gnstrong c=1.86532e-14
c4_28 xdut.dgnd_p xdut.xpad15.gnweak c=1.09066e-14
c4_27 xdut.dgnd_p xdut.xpad15.gpstrong c=1.79115e-15
c4_26 xdut.dgnd_p xdut.xpad15.gpweak c=5.24331e-15
c4_21 xdut.dgnd_p xdut.net2139 c=3.29532e-15
c4_20 xdut.dgnd_p xdut.xpad16.gnstrong c=1.86532e-14
c4_19 xdut.dgnd_p xdut.xpad16.gnweak c=1.09075e-14
c4_18 xdut.dgnd_p xdut.xpad16.gpstrong c=1.79108e-15
c4_17 xdut.dgnd_p xdut.xpad16.gpweak c=5.24556e-15
c4_12 xdut.dgnd_p xdut.resb_p c=2.91721e-13
c4_11 xdut.dgnd_p xdut.tmode_p c=2.91339e-13
c4_10 xdut.dgnd_p xdut.intb_p c=2.90902e-13
c4_9 xdut.dgnd_p xdut.dab_p c=2.91666e-13
c4_8 xdut.dgnd_p xdut.syncb_p c=2.91718e-13
c4_7 xdut.dgnd_p xdut.bfwb_p c=2.91725e-13
c4_6 xdut.dgnd_p xdut.csb_p c=2.90352e-13
c4_5 xdut.dgnd_p xdut.miso_p c=2.89849e-13
c4_4 xdut.dgnd_p xdut.mosi_p c=2.90086e-13
c4_3 xdut.dgnd_p xdut.sck_p c=2.9022e-13
c4_2 xdut.dgnd_p xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=2.1507e-13
c4_1 xdut.dgnd_p xdut.vio_p c=6.9365e-12
cg3_1693 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 0 c=1.15797e-11
c3_1692 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xpad6_gnd.net24 c=2.39021e-15
c3_1691 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xpad6_gnd.net_1 c=3.39434e-14
c3_1690 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xpad5_vcc.net021 c=3.33608e-15
c3_1689 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xpad5_vcc.net_0 c=4.45305e-14
c3_1688 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xpad3_vdd.net_0 c=6.79812e-15
c3_1633 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.xcomp2.nn1 c=4.20519e-15
c3_1632 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.xcomp2.ib_int c=4.42951e-15
c3_1629 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.xcomp1.nn1 c=4.1946e-15
c3_1628 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.xcomp1.ib_int c=4.40886e-15
c3_1611 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.v_tsens_i c=5.52202e-15
c3_1610 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.atst_ts_5v<1> c=1.13563e-15
c3_1609 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.adj_ot_5v<1> c=1.15366e-15
c3_1607 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.net664 c=1.83569e-15
c3_1606 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.net666 c=1.03636e-15
c3_1605 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.xcomp1.enb c=3.0124e-15
c3_1591 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.xsw1.net28 c=1.95885e-15
c3_1589 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.xsw1.enb_int c=2.38586e-15
c3_1588 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.net699 c=1.0256e-15
c3_1587 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.net544 c=2.76916e-15
c3_1584 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.xsw2.net28 c=1.9571e-15
c3_1582 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.xsw2.enb_int c=2.39622e-15
c3_1571 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.otwarn_5v c=3.00548e-15
c3_1570 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.xcomp2.inp c=2.68855e-15
c3_1569 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.net690 c=2.78537e-15
c3_1567 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.xcomp2.nn3 c=1.11647e-15
c3_1566 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.xcomp2.nn2 c=1.26972e-15
c3_1561 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.net680 c=5.06352e-15
c3_1560 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.xcomp1.inp c=2.68283e-15
c3_1559 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.net687 c=5.1501e-15
c3_1557 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.xcomp1.nnvc c=1.95053e-15
c3_1556 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.xcomp1.nn3 c=1.12443e-15
c3_1555 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.xcomp1.nn2 c=1.271e-15
c3_1553 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xtmon.atst_ts_5v<0> c=1.24105e-15
c3_1538 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.xvrrmon.net52 c=6.2023e-15
c3_1526 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.xvrrmon.ena c=5.92698e-15
c3_1515 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.xvrrmon.net18 c=1.56616e-15
c3_1512 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.xvrrmon.net54 c=1.20742e-15
c3_1480 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.xvddreg.ibn1u c=4.21304e-15
c3_1470 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.xvddreg.net224 c=3.46357e-15
c3_1408 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.vcc_uv_5v c=1.74392e-15
c3_1400 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.xvccreg.net68 c=3.4833e-15
c3_1379 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.xvbgbuf.vg_m5 c=8.77506e-15
c3_1378 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.xvbgbuf.vgpc c=7.38763e-15
c3_1377 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.xvbgbuf.net163 c=1.49911e-14
c3_1376 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.xvbgbuf.vgp c=5.88231e-14
c3_1263 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.ibp10u<0> c=6.04679e-15
c3_1259 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.xref.ibp1u<0> c=3.58335e-15
c3_1238 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.atst_sup_5v<4> c=2.42049e-15
c3_1234 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.i_trim_5v<0> c=3.5599e-15
c3_1233 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.i_trim_5v<1> c=1.34368e-15
c3_1230 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.ibp10u<3> c=1.06102e-15
c3_1229 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.xref.iaux10u c=2.1743e-15
c3_1227 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.i_trim_5v<2> c=1.0313e-15
c3_1226 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.ibp5u<1> c=5.52001e-15
c3_1224 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.ic5u<12> c=1.40644e-15
c3_1219 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.i_trim_5v<3> c=1.03976e-15
c3_1214 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.xvrrmon.net9 c=2.02803e-15
c3_1212 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.ibp10u<1> c=3.2981e-15
c3_1210 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.xvrrmon.net42 c=3.22783e-15
c3_1197 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.atst_sup_5v<0> c=1.31196e-15
c3_1196 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.atst_sup_5v<1> c=1.40468e-15
c3_1192 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.atst_sup_5v<2> c=1.29904e-15
c3_1186 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xsup.atst_sup_5v<3> c=1.19854e-15
c3_1183 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.ic5u<7> c=1.3924e-15
c3_1182 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.ic5u<2> c=1.4292e-15
c3_1180 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.ic5u<6> c=6.00595e-15
c3_1178 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xotpmux.xsw3.net28 c=1.98191e-15
c3_1134 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xotpmux.xsw0.net28 c=1.96699e-15
c3_1132 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xotpmux.xsw1.net28 c=2.00232e-15
c3_1128 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xotpmux.xsw2.net28 c=1.96599e-15
c3_1122 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xldo.xuvcomp.nn1 c=4.16407e-15
c3_1121 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xldo.xuvcomp.ib_int c=4.59977e-15
c3_1120 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xldo.xamp.cms c=2.16469e-15
c3_1117 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xldo.net636 c=5.26958e-15
c3_1112 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xldo.xsw_atb.net28 c=1.98172e-15
c3_1103 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xldo.xamp.ena c=1.4579e-15
c3_1099 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xldo.xamp.vpb c=7.32208e-15
c3_1098 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xldo.xamp.gl c=6.54346e-15
c3_1097 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xldo.xamp.glm c=1.21319e-14
c3_1096 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xldo.ota_out c=5.01753e-15
c3_1095 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xldo.xamp.gr c=3.50673e-15
c3_1091 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xldo.vdsi_off_5v c=2.46868e-15
c3_1087 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xldo.vdsi_on_5v c=1.20676e-15
c3_1086 xdut.xana.xdsi_ch1<1>.xtx.xi44.xu42-net12 xdut.xana.xldo.vdsi2atb_5v c=1.58103e-15
c3_831 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xtx.xi44.net7 c=1.21377e-15
c3_830 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xtx.net935 c=1.17974e-15
c3_829 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.tx_5v c=1.33226e-15
c3_828 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.on_5v_int c=2.80005e-15
c3_827 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.on_5v_n c=5.4904e-15
c3_813 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.on_osb_2 c=1.08847e-15
c3_811 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.on_osb_1 c=1.06649e-15
c3_810 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.on_os_0 c=1.86894e-15
c3_809 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.on_osb_0 c=1.47754e-15
c3_808 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.ios_sum c=7.82823e-15
c3_806 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.vbp c=8.96518e-15
c3_805 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.net24 c=1.63677e-15
c3_804 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.net23 c=6.54391e-15
c3_798 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.on_osb_2 c=1.06098e-15
c3_796 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.on_osb_1 c=1.06371e-15
c3_795 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.on_os_0 c=1.81173e-15
c3_794 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.on_osb_0 c=1.48026e-15
c3_793 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.ios_sum c=7.83417e-15
c3_791 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.vbp c=8.9737e-15
c3_790 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.net24 c=1.63483e-15
c3_789 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.net23 c=6.14717e-15
c3_787 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.nd4 c=2.63765e-15
c3_782 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.onb_1 c=1.0516e-15
c3_780 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.onb_2 c=1.05201e-15
c3_778 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.onb_3 c=1.0509e-15
c3_776 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.onb_4 c=1.05451e-15
c3_775 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.idac2atb_5v_b c=7.27858e-15
c3_770 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.onb_0 c=1.01572e-15
c3_759 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.pbias2_cs c=4.04557e-14
c3_756 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.on_os_3 c=1.08696e-15
c3_755 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.on_osb_3 c=1.76101e-15
c3_754 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.on_os_3 c=1.12011e-15
c3_753 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.on_osb_3 c=2.37326e-15
c3_748 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.pbias1_cs c=1.5141e-14
c3_743 xdut.vcc_p xdut.xana.ln_dsi_ch1<1>.rx.ls8.n_59 c=1.10541e-15
c3_740 xdut.vcc_p xdut.net178 c=1.15031e-15
c3_739 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.data_comp_in c=1.02717e-15
c3_738 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.xi232.net7 c=1.13324e-15
c3_737 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.n7 c=3.94124e-15
c3_736 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.xi106.p0 c=1.81199e-15
c3_734 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.on_v5v_ana_b c=1.06523e-15
c3_728 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xiq_cmp.n6 c=1.30482e-15
c3_725 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xhs_sup.mn_hv_lim_d c=3.41123e-15
c3_724 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xhs_sup.on_v5v_ana_i c=2.0064e-15
c3_723 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xhs_sup.on_v5v_ana_b c=1.32795e-15
c3_722 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xhs_sup.pdio_lv c=1.85465e-14
c3_721 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xhs_sup.nd_mncas c=2.97535e-15
c3_718 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xdat2_cmp.data_comp_in c=1.01526e-15
c3_717 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xdat2_cmp.xi232.net7 c=1.10907e-15
c3_716 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xdat2_cmp.xi108.net6 c=1.30237e-15
c3_714 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xdat2_cmp.xi106.p0 c=1.81051e-15
c3_712 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xdat2_cmp.cmp_out_ana c=2.55696e-15
c3_711 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xdat2_cmp.n7 c=4.06868e-15
c3_710 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xdat2_cmp.on_v5v_ana_b c=1.02849e-15
c3_705 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xdat1_cmp.data_comp_in c=1.01308e-15
c3_704 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xdat1_cmp.xi232.net7 c=1.10868e-15
c3_703 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xdat1_cmp.xi108.net6 c=1.30715e-15
c3_701 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xdat1_cmp.xi106.p0 c=1.81202e-15
c3_699 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xdat1_cmp.cmp_out_ana c=2.51075e-15
c3_698 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xdat1_cmp.n7 c=4.09866e-15
c3_697 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xdat1_cmp.on_v5v_ana_b c=1.0284e-15
c3_686 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.rxd2_5v c=3.96129e-15
c3_668 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.noffset_bias1 c=5.39799e-15
c3_667 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.on_v5v_ana_b c=1.53406e-15
c3_666 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.on_v5v_ana_i c=2.70814e-15
c3_662 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.noffset_bias2 c=1.84665e-15
c3_657 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.idac_bias2 c=2.9779e-15
c3_656 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.idac_bias1 c=4.59422e-15
c3_655 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.bias_idac_cas c=1.08694e-15
c3_651 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.trim_dcmp1_5v<3> c=1.82634e-15
c3_647 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.trim_dcmp1_5v<2> c=1.4954e-15
c3_639 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.trim_dcmp1_5v<1> c=1.61905e-15
c3_635 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.trim_dcmp1_5v<0> c=2.1443e-15
c3_634 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.trim_dcmp2_5v<3> c=1.30349e-15
c3_630 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.trim_dcmp2_5v<2> c=1.09781e-15
c3_624 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.trim_dcmp2_5v<1> c=1.22447e-15
c3_619 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.trim_dcmp2_5v<0> c=1.86406e-15
c3_618 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.flt_fast_5v c=1.1441e-15
c3_604 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xls8.net107 c=1.58968e-15
c3_600 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.dat2_sw_d c=4.17437e-15
c3_599 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.dat1_sw_d c=2.90355e-15
c3_598 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.idat_os_summe c=4.03103e-15
c3_597 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.idat_os_summe c=1.50464e-15
c3_582 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.kibg c=1.12893e-13
c3_581 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.net1728 c=3.96301e-15
c3_580 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.net1726 c=2.15476e-14
c3_579 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.vdmpo<1> c=4.38963e-15
c3_578 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.net1727 c=1.45821e-14
c3_577 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.net1730 c=8.21366e-15
c3_576 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_d2i_0.xtx_d2i_idac_0.net1196 c=3.04053e-15
c3_575 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_d2i_0.xtx_d2i_idac_0.net1195 c=1.49107e-15
c3_488 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.vh05 c=2.01809e-15
c3_487 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vbp_5v c=2.44246e-13
c3_486 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xdsi_monitor<0>.net65 c=3.97743e-15
c3_485 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vbtldf c=6.18627e-14
c3_484 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.vh05ov c=2.68994e-15
c3_483 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xdsi_monitor<1>.net65 c=4.04335e-15
c3_481 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.atst_tx_5v<0> c=4.72218e-15
c3_480 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.atst_tx_5v<4> c=1.67326e-15
c3_479 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.atst_tx_5v<3> c=1.43476e-15
c3_478 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.atst_tx_5v<2> c=1.9829e-15
c3_463 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vbn_5v c=2.41864e-15
c3_455 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.inn_5v c=1.22901e-14
c3_451 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.vdsi_ok_5v c=2.88764e-15
c3_447 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.tx_data_5v<4> c=6.43453e-15
c3_444 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.tx_data_5v<3> c=2.26387e-15
c3_439 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.tx_data_5v<2> c=1.87355e-15
c3_438 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.tx_data_5v<1> c=1.9463e-15
c3_435 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vncin2_ctrl c=3.4271e-15
c3_432 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xi44.xu42-net12 c=8.5853e-15
c3_428 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.on_tx_5v c=3.17226e-15
c3_425 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xdsi_monitor<1>.net28 c=2.69412e-15
c3_424 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xdsi_monitor<1>.net80 c=1.33966e-15
c3_423 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.vdsi_ov_5v c=1.82471e-15
c3_422 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vnglim c=5.22029e-15
c3_421 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vdiffo c=2.65503e-15
c3_420 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2240 c=7.89026e-15
c3_417 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2536 c=1.54318e-14
c3_416 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xdsi_monitor<0>.net80 c=1.3023e-15
c3_415 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vncin2 c=4.57065e-15
c3_412 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xdsi_monitor<0>.net28 c=2.06128e-15
c3_408 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.tx_data_5v<0> c=2.59662e-15
c3_403 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.atst_tx_5v<6> c=2.92301e-15
c3_390 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.vdsi_ctrl_5v<2> c=3.46894e-15
c3_385 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.vdsi_ctrl_5v<1> c=2.04654e-15
c3_384 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.i5u_int_5v<0> c=1.29549e-14
c3_383 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.idac_5v<1> c=4.87748e-14
c3_382 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.i5u_int_5v<1> c=7.48649e-15
c3_379 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.vdsi_ctrl_5v<0> c=3.40657e-15
c3_375 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.idac_5v<2> c=2.85474e-13
c3_372 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.rx_txn_5v c=2.66114e-15
c3_371 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.vdsi_ctrl_l_5v<2> c=5.7897e-15
c3_370 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.vdsi_ctrl_l_5v<1> c=4.5094e-15
c3_369 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_imirror_0.vdsi_ctrl_l_5v<0> c=1.41102e-15
c3_338 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.atst_tx_5v<5> c=2.01099e-15
c3_332 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.ibg10u_5v<1> c=2.47249e-15
c3_325 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xi44.net7 c=1.20205e-15
c3_324 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.net935 c=1.1752e-15
c3_323 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.tx_5v c=1.33503e-15
c3_322 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.on_5v_int c=2.79819e-15
c3_321 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.on_5v_n c=5.51225e-15
c3_311 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xtx.atst_tx_5v<1> c=2.26921e-15
c3_306 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim2.on_osb_2 c=1.10237e-15
c3_304 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim2.on_osb_1 c=1.0887e-15
c3_303 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim2.on_os_0 c=1.86851e-15
c3_302 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim2.on_osb_0 c=1.47754e-15
c3_301 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim2.ios_sum c=7.84692e-15
c3_299 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim2.vbp c=8.96313e-15
c3_298 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim2.net24 c=1.63718e-15
c3_297 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim2.net23 c=6.55227e-15
c3_291 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim1.on_osb_2 c=1.07315e-15
c3_289 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim1.on_osb_1 c=1.08784e-15
c3_288 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim1.on_os_0 c=1.81085e-15
c3_287 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim1.on_osb_0 c=1.481e-15
c3_286 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim1.ios_sum c=7.85036e-15
c3_284 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim1.vbp c=8.97123e-15
c3_283 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim1.net24 c=1.63542e-15
c3_282 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim1.net23 c=6.15638e-15
c3_280 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.nd4 c=3.78107e-15
c3_277 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.nsdum c=1.07478e-15
c3_275 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.onb_1 c=1.25122e-15
c3_273 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.onb_2 c=1.25157e-15
c3_271 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.onb_3 c=1.25535e-15
c3_269 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.onb_4 c=1.27506e-15
c3_268 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.idac2atb_5v_b c=1.2542e-14
c3_264 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.nd0 c=1.28205e-15
c3_262 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.onb_0 c=1.2234e-15
c3_261 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.nd1 c=1.54187e-15
c3_259 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.nd2 c=1.67297e-15
c3_257 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.nd3 c=2.4066e-15
c3_251 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim1.on_osb_3 c=1.74575e-15
c3_250 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim2.on_osb_3 c=2.36064e-15
c3_243 xdut.vcc_p xdut.xana.ln_dsi_ch1<0>.rx.ls8.n_59 c=1.10592e-15
c3_227 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.coms1 c=3.86736e-15
c3_226 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.vbn c=4.43873e-15
c3_224 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.xst.net70 c=1.94969e-15
c3_222 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.cmp_out_dig c=1.8763e-15
c3_221 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.xst.net44 c=1.20909e-15
c3_219 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.data_comp_in c=1.6969e-15
c3_218 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.xi232.net7 c=1.25548e-15
c3_217 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.xst.net72 c=5.16155e-15
c3_216 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.n7 c=4.53366e-15
c3_215 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.xi106.p0 c=1.88736e-15
c3_214 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.xi232.x_u4-net13 c=1.39413e-15
c3_213 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.on_v5v_ana_b c=1.23288e-15
c3_211 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.n4 c=4.57925e-15
c3_205 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.n3 c=5.1278e-15
c3_202 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.n2 c=1.06768e-15
c3_197 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.coms2 c=3.20922e-15
c3_194 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.n5 c=4.72527e-15
c3_193 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.n6 c=4.40116e-15
c3_192 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.preamp_r c=3.10064e-15
c3_191 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.preamp_l c=4.2035e-15
c3_190 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.pdio1 c=2.72312e-15
c3_189 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.pdio2 c=2.61597e-15
c3_187 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xhs_sup.on_v5v_ana_i c=2.00737e-15
c3_186 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xhs_sup.on_v5v_ana_b c=1.32886e-15
c3_185 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xhs_sup.pdio_lv c=1.85488e-14
c3_180 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xdat2_cmp.data_comp_in c=1.01448e-15
c3_179 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xdat2_cmp.xi232.net7 c=1.10933e-15
c3_178 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xdat2_cmp.xi108.net6 c=1.30398e-15
c3_176 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xdat2_cmp.xi106.p0 c=1.80548e-15
c3_174 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xdat2_cmp.cmp_out_ana c=2.54602e-15
c3_173 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xdat2_cmp.n7 c=4.09438e-15
c3_172 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xdat2_cmp.on_v5v_ana_b c=1.02819e-15
c3_169 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xdat1_cmp.data_comp_in c=1.01168e-15
c3_168 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xdat1_cmp.xi232.net7 c=1.10851e-15
c3_167 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xdat1_cmp.xi108.net6 c=1.30707e-15
c3_165 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xdat1_cmp.xi106.p0 c=1.80677e-15
c3_163 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xdat1_cmp.cmp_out_ana c=2.51163e-15
c3_162 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xdat1_cmp.n7 c=4.12478e-15
c3_161 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xdat1_cmp.on_v5v_ana_b c=1.0281e-15
c3_152 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.idac_5v<1> c=2.56862e-15
c3_151 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.iq_cmp_5v c=9.59592e-15
c3_150 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.idac_5v<0> c=2.9247e-15
c3_149 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.idac_5v<2> c=2.68534e-15
c3_133 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.inp_iqcmp c=9.62924e-15
c3_132 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.net899 c=1.07738e-15
c3_130 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.on_v5v_ana_b c=1.52756e-15
c3_129 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.on_v5v_ana_i c=2.71107e-15
c3_124 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.inn_iqcmp c=1.09112e-14
c3_120 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.trim_dcmp1_5v<3> c=1.83214e-15
c3_116 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.trim_dcmp1_5v<2> c=1.50005e-15
c3_109 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.trim_dcmp1_5v<1> c=1.61939e-15
c3_105 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.trim_dcmp1_5v<0> c=2.15171e-15
c3_104 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.trim_dcmp2_5v<3> c=1.30639e-15
c3_100 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.trim_dcmp2_5v<2> c=1.10263e-15
c3_94 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.trim_dcmp2_5v<1> c=1.22502e-15
c3_89 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.trim_dcmp2_5v<0> c=1.86208e-15
c3_88 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.flt_fast_5v c=1.16105e-15
c3_75 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.idac_5v<4> c=3.35477e-15
c3_74 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.idac_5v<3> c=4.69037e-15
c3_73 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.idac2atb_5v c=3.48836e-15
c3_71 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xls8.net107 c=1.58895e-15
c3_67 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.dat2_sw_d c=4.16557e-15
c3_66 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.dat1_sw_d c=2.89001e-15
c3_64 xdut.vcc_p xdut.xana.ic5u<11> c=1.09326e-15
c3_62 xdut.vcc_p xdut.xana.net875 c=1.13067e-14
c3_47 xdut.vcc_p xdut.trim_dsi_rx2<4> c=4.24033e-15
c3_46 xdut.vcc_p xdut.trim_dsi_rx2<5> c=4.3761e-15
c3_45 xdut.vcc_p xdut.trim_dsi_rx2<6> c=4.23351e-15
c3_44 xdut.vcc_p xdut.trim_dsi_rx1<5> c=4.21509e-15
c3_43 xdut.vcc_p xdut.trim_dsi_rx1<4> c=4.20736e-15
c3_42 xdut.vcc_p xdut.trim_dsi_rx2<7> c=4.01889e-15
c3_41 xdut.vcc_p xdut.trim_dsi_rx1<6> c=3.85686e-15
c3_40 xdut.vcc_p xdut.dsi_rx_on<1> c=4.26828e-15
c3_39 xdut.vcc_p xdut.trim_dsi_rx1<7> c=4.20753e-15
c3_38 xdut.vcc_p xdut.atst_rx<1> c=4.61551e-15
c3_37 xdut.vcc_p xdut.dsi_rxd2<1> c=4.46057e-15
c3_36 xdut.vcc_p xdut.dsi_rx_filter_fast<1> c=4.24079e-15
c3_35 xdut.vcc_p xdut.dsi_rxd1<1> c=4.40765e-15
c3_34 xdut.vcc_p xdut.dsi_tx_tbit_cfg<3> c=2.929e-15
c3_33 xdut.vcc_p xdut.atst_tx<13> c=2.7562e-15
c3_32 xdut.vcc_p xdut.dsi_ov<1> c=8.49155e-15
c3_31 xdut.vcc_p xdut.dsi_rx_txn<1> c=3.8382e-15
c3_30 xdut.vcc_p xdut.dsi_tx_data<9> c=4.23248e-15
c3_29 xdut.vcc_p xdut.dsi_tx_tbit_cfg<2> c=2.93876e-15
c3_28 xdut.vcc_p xdut.dsi_idac<7> c=3.05192e-15
c3_27 xdut.vcc_p xdut.dsi_idac<8> c=4.14961e-15
c3_26 xdut.vcc_p xdut.dsi_idac<5> c=3.43632e-15
c3_25 xdut.vcc_p xdut.dsi_idac<9> c=4.30634e-15
c3_24 xdut.vcc_p xdut.dsi_idac<6> c=2.41592e-15
c3_23 xdut.vcc_p xdut.dsi_icmp<1> c=4.54822e-15
c3_22 xdut.vcc_p xdut.dsi_tx_data<7> c=4.33444e-15
c3_21 xdut.vcc_p xdut.dsi_tx_data<8> c=4.50153e-15
c3_20 xdut.vcc_p xdut.dsi_tx_data<5> c=4.42795e-15
c3_19 xdut.vcc_p xdut.dsi_tx_data<6> c=4.32608e-15
c3_18 xdut.vcc_p xdut.xana.xldo.vs_m0 c=7.17186e-15
c3_17 xdut.vcc_p xdut.xana.xldo.vbp_lim c=2.17719e-15
c3_16 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.offs_sw_d c=1.69898e-14
c3_15 xdut.vcc_p xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.isum c=3.3832e-15
c3_14 xdut.vcc_p xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.isum c=1.76771e-14
c3_13 xdut.vcc_p xdut.xana.xsup.xvddreg.xvddreg.net339 c=9.44481e-15
c3_12 xdut.vcc_p xdut.xana.xsup.xvccreg.xreg.n2_net c=6.19197e-15
c3_11 xdut.vcc_p xdut.xana.xsup.xvccreg.xreg.n1_net c=7.01994e-15
c3_9 xdut.vcc_p xdut.xana.xsup.xvccreg.xreg.net851 c=4.21781e-15
c3_7 xdut.vcc_p xdut.xana.xsup.xvccreg.xreg.vbat c=1.54338e-13
c3_6 xdut.vcc_p xdut.xpad6_gnd.net_0 c=1.10575e-14
c3_5 xdut.vcc_p xdut.xpad6_gnd.net_2 c=1.10067e-14
c3_4 xdut.vcc_p xdut.xpad5_vcc.net_1 c=2.46395e-14
c3_3 xdut.vcc_p xdut.xpad5_vcc.net_2 c=2.23933e-14
c3_1 xdut.vcc_p xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 c=1.69452e-12
cg2_2239 xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 0 c=1.40335e-11
c2_2227 xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 xdut.xpad24.cb c=1.97273e-15
c2_2201 xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 xdut.xpad23.cb c=1.972e-15
c2_2175 xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 xdut.xpad22.cb c=1.97201e-15
c2_2149 xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 xdut.xpad21.cb c=1.97201e-15
c2_2129 xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 xdut.xpad2.ibb c=1.1961e-15
c2_2123 xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 xdut.xpad2.cb c=1.96924e-15
c2_2097 xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 xdut.xpad18.cb c=1.96529e-15
c2_2075 xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 xdut.xpad17.cb c=1.96764e-15
c2_2049 xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 xdut.xpad16.cb c=1.96873e-15
c2_2023 xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 xdut.xpad15.cb c=1.96486e-15
c2_1997 xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 xdut.xpad14.cb c=1.96508e-15
c2_1971 xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 xdut.xpad13.cb c=1.96505e-15
c2_1952 xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 xdut.xpad1.ibb c=1.19359e-15
c2_1947 xdut.xosc.xosc_20m_0.xosc20m_0.xres.xdec3_top.xi1.xi0_p2 xdut.xpad1.cb c=1.96505e-15
c2_862 xdut.vdd_p xdut.xosc.xosc_20m_0.xosc20m_0.inp c=4.08097e-15
c2_824 xdut.vdd_p xdut.xosc.xosc_20m_0.xosc20m_0.xcs_top.vstart c=1.36337e-15
c2_818 xdut.vdd_p xdut.xosc.xclkref_lpf_0.net70 c=1.08114e-15
c2_771 xdut.vdd_p xdut.xana.xsup.xvddreg.xvddreg.net326 c=2.62138e-15
c2_768 xdut.vdd_p xdut.xana.xsup.xvddreg.xvddreg.net379 c=1.03655e-15
c2_767 xdut.vdd_p xdut.xana.xsup.xvddreg.xvddreg.gate c=9.6894e-14
c2_766 xdut.vdd_p xdut.xana.xsup.xvddreg.xvddreg.vref_flt c=1.8947e-15
c2_763 xdut.vdd_p xdut.xana.xsup.xvddreg.xvddreg.vfbi c=4.65304e-13
c2_762 xdut.vdd_p xdut.xana.xsup.xvddreg.xvddreg.net356 c=3.17938e-15
c2_757 xdut.vdd_p xdut.xana.xsup.xvccreg.xreg.nbl1 c=3.03959e-14
c2_748 xdut.vdd_p xdut.xana.xsup.xvddreg.xrdiv.net118 c=1.40144e-15
c2_739 xdut.vdd_p xdut.xana.xsup.xvddreg.rdiv<33> c=1.48558e-15
c2_737 xdut.vdd_p xdut.xana.xsup.xvddreg.net153 c=1.62628e-15
c2_732 xdut.vdd_p xdut.xana.xsup.xmux.xsw2.net28 c=1.20554e-15
c2_680 xdut.vdd_p xdut.xana.xsup.atst_sup_5v<2> c=1.25441e-15
c2_634 xdut.vdd_p xdut.xana.xldo.xvref.sel_1 c=1.1186e-15
c2_632 xdut.vdd_p xdut.xana.xldo.xvref.sel_0 c=1.61816e-15
c2_615 xdut.vdd_p xdut.xana.xldo.xvref.bit<2> c=2.74239e-15
c2_614 xdut.vdd_p xdut.xana.xldo.xvref.bit<1> c=2.72525e-15
c2_613 xdut.vdd_p xdut.xana.xldo.xvref.bit<0> c=4.41533e-15
c2_596 xdut.vdd_p xdut.xana.xldo.xvref.b2n c=4.62362e-15
c2_595 xdut.vdd_p xdut.xana.xldo.xvref.b1n c=1.76826e-15
c2_594 xdut.vdd_p xdut.xana.xldo.xvref.b0n c=1.44459e-15
c2_589 xdut.vdd_p xdut.xana.xldo.xvref.sel_5 c=1.00187e-15
c2_586 xdut.vdd_p xdut.xana.xldo.xvref.sel_4 c=1.03257e-15
c2_584 xdut.vdd_p xdut.xana.xldo.xvref.sel_3 c=1.04837e-15
c2_583 xdut.vdd_p xdut.xana.xldo.xvref.sel_2 c=1.06591e-15
c2_160 xdut.vdd_p xdut.xana.net875 c=1.10688e-14
c2_141 xdut.vdd_p xdut.net2135 c=1.14229e-15
c2_140 xdut.vdd_p xdut.xpad17.aoutbb c=1.39953e-15
c2_139 xdut.vdd_p xdut.net2134 c=1.1431e-15
c2_138 xdut.vdd_p xdut.net2456 c=1.39546e-15
c2_136 xdut.vdd_p xdut.xpad18.aoutbb c=1.39949e-15
c2_135 xdut.vdd_p xdut.net2138 c=1.14289e-15
c2_134 xdut.vdd_p xdut.net2140 c=1.13122e-15
c2_133 xdut.vdd_p xdut.xpad2.aoutbb c=1.41309e-15
c2_132 xdut.vdd_p xdut.xpad21.aoutbb c=1.41692e-15
c2_131 xdut.vdd_p xdut.net2130 c=1.14865e-15
c2_130 xdut.vdd_p xdut.xpad22.aoutbb c=1.41692e-15
c2_129 xdut.vdd_p xdut.net2131 c=1.14613e-15
c2_128 xdut.vdd_p xdut.xpad23.aoutbb c=1.41692e-15
c2_127 xdut.vdd_p xdut.net2132 c=1.14865e-15
c2_126 xdut.vdd_p xdut.trim_dsi_rx2<4> c=1.72536e-15
c2_112 xdut.vdd_p xdut.intb_i c=1.37323e-15
c2_111 xdut.vdd_p xdut.dab_i c=1.35981e-15
c2_105 xdut.vdd_p xdut.resb_i c=1.37528e-15
c2_104 xdut.vdd_p xdut.net3137 c=1.43736e-15
c2_102 xdut.vdd_p xdut.syncb_i c=1.356e-15
c2_95 xdut.vdd_p xdut.bfwb_i c=1.37457e-15
c2_93 xdut.vdd_p xdut.bfwb_pd c=1.45976e-15
c2_92 xdut.vdd_p xdut.bfwb_pu c=1.03464e-15
c2_86 xdut.vdd_p xdut.rfc_i c=1.46688e-15
c2_85 xdut.vdd_p xdut.net3135 c=1.37188e-15
c2_83 xdut.vdd_p xdut.sdi_i c=1.36061e-15
c2_78 xdut.vdd_p xdut.sck_pu c=1.37883e-15
c2_77 xdut.vdd_p xdut.sck_pd c=1.28853e-15
c2_76 xdut.vdd_p xdut.sck_o c=1.28697e-15
c2_75 xdut.vdd_p xdut.sck_i c=1.97183e-15
c2_74 xdut.vdd_p xdut.sck_ie c=1.29908e-15
c2_73 xdut.vdd_p xdut.sck_oe c=1.34408e-15
c2_72 xdut.vdd_p xdut.csb_pu c=1.34705e-15
c2_71 xdut.vdd_p xdut.csb_pd c=1.2869e-15
c2_70 xdut.vdd_p xdut.csb_ie c=1.29707e-15
c2_69 xdut.vdd_p xdut.csb_i c=1.94851e-15
c2_68 xdut.vdd_p xdut.csb_oe c=1.65626e-15
c2_67 xdut.vdd_p xdut.csb_o c=1.28033e-15
c2_65 xdut.vdd_p xdut.dsi_rxd2<1> c=1.419e-15
c2_63 xdut.vdd_p xdut.dsi_rxd1<1> c=1.34211e-15
c2_62 xdut.vdd_p xdut.dsi_tx_tbit_cfg<3> c=1.19317e-15
c2_61 xdut.vdd_p xdut.atst_tx<13> c=1.18363e-15
c2_60 xdut.vdd_p xdut.dsi_ov<1> c=2.83795e-15
c2_58 xdut.vdd_p xdut.dsi_tx_data<9> c=1.31391e-15
c2_57 xdut.vdd_p xdut.dsi_tx_tbit_cfg<2> c=1.19744e-15
c2_54 xdut.vdd_p xdut.dsi_idac<5> c=1.27855e-15
c2_52 xdut.vdd_p xdut.dsi_idac<6> c=1.04553e-15
c2_51 xdut.vdd_p xdut.dsi_icmp<1> c=1.36668e-15
c2_50 xdut.vdd_p xdut.xpad24.aoutbb c=1.41692e-15
c2_49 xdut.vdd_p xdut.net3230 c=1.14278e-15
c2_48 xdut.vdd_p xdut.dsi_tx_data<7> c=1.17774e-15
c2_47 xdut.vdd_p xdut.dsi_tx_data<8> c=1.1771e-15
c2_46 xdut.vdd_p xdut.dsi_tx_data<5> c=1.17883e-15
c2_45 xdut.vdd_p xdut.dsi_tx_data<6> c=1.17714e-15
c2_44 xdut.vdd_p xdut.xana.xldo.vs_m0 c=4.20644e-15
c2_40 xdut.vdd_p xdut.xana.xsup.xvddreg.xvddreg.net339 c=1.11171e-14
c2_39 xdut.vdd_p xdut.xana.xldo.vdsi_nbl c=1.41911e-15
c2_18 xdut.vdd_p xdut.net3138 c=1.126e-15
c2_17 xdut.vdd_p xdut.xpad13.aoutbb c=1.39949e-15
c2_16 xdut.vdd_p xdut.xpad14.aoutbb c=1.39949e-15
c2_15 xdut.vdd_p xdut.net2136 c=1.14501e-15
c2_14 xdut.vdd_p xdut.xpad15.aoutbb c=1.39949e-15
c2_13 xdut.vdd_p xdut.net2139 c=1.1472e-15
c2_12 xdut.vdd_p xdut.xpad16.aoutbb c=1.39949e-15
c2_11 xdut.vdd_p xdut.resb_p c=1.93374e-14
c2_10 xdut.vdd_p xdut.tmode_p c=1.94628e-14
c2_9 xdut.vdd_p xdut.intb_p c=1.82088e-14
c2_8 xdut.vdd_p xdut.dab_p c=1.8191e-14
c2_7 xdut.vdd_p xdut.syncb_p c=1.82088e-14
c2_6 xdut.vdd_p xdut.bfwb_p c=2.79378e-14
c2_5 xdut.vdd_p xdut.csb_p c=1.82189e-14
c2_4 xdut.vdd_p xdut.miso_p c=1.83735e-14
c2_3 xdut.vdd_p xdut.mosi_p c=1.83521e-14
c2_2 xdut.vdd_p xdut.sck_p c=1.82553e-14
c2_1 xdut.vdd_p xdut.vio_p c=8.78988e-14
cg1_463 xdut.vio_p 0 c=6.53056e-13
c1_460 xdut.vio_p xdut.xpad24.gpesd c=2.7304e-14
c1_456 xdut.vio_p xdut.xpad23.gpesd c=2.7304e-14
c1_452 xdut.vio_p xdut.xpad22.gpesd c=2.7304e-14
c1_448 xdut.vio_p xdut.xpad21.gpesd c=2.73041e-14
c1_446 xdut.vio_p xdut.xpad19_vio.net021 c=2.43906e-15
c1_445 xdut.vio_p xdut.xpad19_vio.net_0 c=3.3991e-14
c1_442 xdut.vio_p xdut.xpad2.gpesd c=2.72842e-14
c1_440 xdut.vio_p xdut.xi74.net021 c=3.33279e-15
c1_439 xdut.vio_p xdut.xi74.net_0 c=4.45299e-14
c1_436 xdut.vio_p xdut.xpad18.gpesd c=2.73052e-14
c1_432 xdut.vio_p xdut.xpad17.gpesd c=2.73054e-14
c1_428 xdut.vio_p xdut.xpad16.gpesd c=2.73054e-14
c1_424 xdut.vio_p xdut.xpad15.gpesd c=2.73053e-14
c1_420 xdut.vio_p xdut.xpad14.gpesd c=2.73051e-14
c1_416 xdut.vio_p xdut.xpad13.gpesd c=2.73053e-14
c1_412 xdut.vio_p xdut.xi75.net021 c=3.33608e-15
c1_411 xdut.vio_p xdut.xi75.net_0 c=4.45286e-14
c1_410 xdut.vio_p xdut.xpad20_gndio.net24 c=3.3361e-15
c1_409 xdut.vio_p xdut.xpad20_gndio.net_1 c=4.45293e-14
c1_407 xdut.vio_p xdut.xpad16.aoutb c=2.71421e-15
c1_406 xdut.vio_p xdut.xpad16.dst2 c=1.56096e-15
c1_405 xdut.vio_p xdut.net2135 c=1.02859e-14
c1_403 xdut.vio_p xdut.xpad17.gn c=1.69274e-15
c1_402 xdut.vio_p xdut.xpad17.xlsgn.o1b c=1.08879e-15
c1_400 xdut.vio_p xdut.xpad17.gnstrong c=3.79192e-15
c1_399 xdut.vio_p xdut.xpad17.gnweak c=1.1185e-14
c1_398 xdut.vio_p xdut.xpad17.gpstrong c=4.49271e-14
c1_397 xdut.vio_p xdut.xpad17.gpweak c=2.0486e-14
c1_396 xdut.vio_p xdut.xpad17.gp c=1.86871e-15
c1_394 xdut.vio_p xdut.xpad17.xlsgp.o1b c=1.07888e-15
c1_392 xdut.vio_p xdut.xpad17.ds_ls c=1.51202e-15
c1_391 xdut.vio_p xdut.xpad17.dsb_ls c=3.41017e-15
c1_390 xdut.vio_p xdut.xpad17.xlsds.o1b c=1.12984e-15
c1_389 xdut.vio_p xdut.xpad17.xlsds.o1 c=1.00701e-15
c1_387 xdut.vio_p xdut.xpad17.ie_ls c=1.76025e-15
c1_385 xdut.vio_p xdut.xpad17.xlsie.o1b c=1.09969e-15
c1_384 xdut.vio_p xdut.xpad17.xlsie.o1 c=1.00531e-15
c1_383 xdut.vio_p xdut.xpad2.ds_ls c=1.50335e-15
c1_382 xdut.vio_p xdut.xpad2.dsb_ls c=3.34793e-15
c1_381 xdut.vio_p xdut.xpad2.xlsds.o1b c=1.14923e-15
c1_380 xdut.vio_p xdut.xpad2.xlsds.o1 c=1.00575e-15
c1_379 xdut.vio_p xdut.xpad2.gp c=1.86606e-15
c1_377 xdut.vio_p xdut.xpad2.xlsgp.o1b c=1.08274e-15
c1_376 xdut.vio_p xdut.xpad2.xlsgn.o1b c=1.09096e-15
c1_372 xdut.vio_p xdut.xpad2.gn c=1.69173e-15
c1_371 xdut.vio_p xdut.xpad2.gnstrong c=3.79776e-15
c1_370 xdut.vio_p xdut.xpad2.gnweak c=1.12881e-14
c1_369 xdut.vio_p xdut.xpad2.gpstrong c=4.48905e-14
c1_368 xdut.vio_p xdut.xpad2.gpweak c=2.04843e-14
c1_367 xdut.vio_p xdut.xpad17.aoutbb c=1.21823e-15
c1_365 xdut.vio_p xdut.xpad17.pub_ls c=1.64428e-15
c1_364 xdut.vio_p xdut.xpad17.xlspu.o1b c=1.0793e-15
c1_361 xdut.vio_p xdut.xpad17.xlspd.o1b c=1.08285e-15
c1_358 xdut.vio_p xdut.xpad17.dst2 c=1.56061e-15
c1_357 xdut.vio_p xdut.xpad17.aoutb c=2.71421e-15
c1_356 xdut.vio_p xdut.net2134 c=1.02623e-14
c1_354 xdut.vio_p xdut.xpad18.xlsgp.o1b c=1.07708e-15
c1_352 xdut.vio_p xdut.xpad18.xlsds.o1b c=1.12972e-15
c1_351 xdut.vio_p xdut.xpad18.xlsds.o1 c=1.00701e-15
c1_350 xdut.vio_p xdut.xpad1.dst2 c=1.53217e-15
c1_349 xdut.vio_p xdut.xpad1.aoutb c=2.687e-15
c1_348 xdut.vio_p xdut.net2456 c=1.0277e-14
c1_346 xdut.vio_p xdut.xpad1.pub_ls c=1.63224e-15
c1_345 xdut.vio_p xdut.xpad1.xlspu.o1b c=1.07505e-15
c1_342 xdut.vio_p xdut.xpad1.xlspd.o1b c=1.08403e-15
c1_338 xdut.vio_p xdut.xpad18.ie_ls c=1.76174e-15
c1_336 xdut.vio_p xdut.xpad18.xlsie.o1b c=1.09969e-15
c1_335 xdut.vio_p xdut.xpad18.xlsie.o1 c=1.00531e-15
c1_331 xdut.vio_p xdut.xpad18.xlspd.o1b c=1.08285e-15
c1_329 xdut.vio_p xdut.xpad18.aoutbb c=1.21815e-15
c1_327 xdut.vio_p xdut.xpad18.pub_ls c=1.64424e-15
c1_326 xdut.vio_p xdut.xpad18.xlspu.o1b c=1.0793e-15
c1_324 xdut.vio_p xdut.xpad18.dst2 c=1.56061e-15
c1_323 xdut.vio_p xdut.xpad18.aoutb c=2.7126e-15
c1_322 xdut.vio_p xdut.net2138 c=1.03144e-14
c1_321 xdut.vio_p xdut.xpad1.gp c=1.87033e-15
c1_319 xdut.vio_p xdut.xpad1.xlsgp.o1b c=1.08274e-15
c1_318 xdut.vio_p xdut.xpad1.ds_ls c=1.50933e-15
c1_317 xdut.vio_p xdut.xpad1.dsb_ls c=3.35435e-15
c1_316 xdut.vio_p xdut.xpad1.xlsds.o1b c=1.15319e-15
c1_315 xdut.vio_p xdut.xpad1.xlsds.o1 c=1.00575e-15
c1_313 xdut.vio_p xdut.xpad1.gn c=1.69194e-15
c1_312 xdut.vio_p xdut.xpad1.xlsgn.o1b c=1.09096e-15
c1_309 xdut.vio_p xdut.xpad1.gnstrong c=3.79919e-15
c1_308 xdut.vio_p xdut.xpad1.gpstrong c=4.48993e-14
c1_307 xdut.vio_p xdut.net2140 c=1.02918e-14
c1_306 xdut.vio_p xdut.xpad2.dst2 c=1.53105e-15
c1_305 xdut.vio_p xdut.xpad2.aoutb c=2.69315e-15
c1_304 xdut.vio_p xdut.xpad2.aoutbb c=1.2013e-15
c1_302 xdut.vio_p xdut.xpad2.pub_ls c=1.63418e-15
c1_301 xdut.vio_p xdut.xpad2.xlspu.o1b c=1.07514e-15
c1_297 xdut.vio_p xdut.xpad2.xlspd.o1b c=1.09053e-15
c1_294 xdut.vio_p xdut.xpad2.ie_ls c=1.76608e-15
c1_292 xdut.vio_p xdut.xpad2.xlsie.o1b c=1.11305e-15
c1_291 xdut.vio_p xdut.xpad2.xlsie.o1 c=1.01392e-15
c1_290 xdut.vio_p xdut.xpad21.aoutbb c=1.19949e-15
c1_289 xdut.vio_p xdut.xpad21.dst2 c=1.52865e-15
c1_288 xdut.vio_p xdut.xpad21.aoutb c=2.67719e-15
c1_287 xdut.vio_p xdut.net2130 c=1.0273e-14
c1_285 xdut.vio_p xdut.xpad21.pub_ls c=1.62948e-15
c1_284 xdut.vio_p xdut.xpad21.xlspu.o1b c=1.07292e-15
c1_282 xdut.vio_p xdut.xpad21.xlspd.o1b c=1.08373e-15
c1_277 xdut.vio_p xdut.xpad21.ie_ls c=1.74546e-15
c1_275 xdut.vio_p xdut.xpad21.xlsie.o1b c=1.10672e-15
c1_274 xdut.vio_p xdut.xpad21.xlsie.o1 c=1.01402e-15
c1_273 xdut.vio_p xdut.xpad21.ds_ls c=1.4963e-15
c1_272 xdut.vio_p xdut.xpad21.dsb_ls c=3.35306e-15
c1_271 xdut.vio_p xdut.xpad21.xlsds.o1b c=1.13657e-15
c1_270 xdut.vio_p xdut.xpad21.xlsds.o1 c=1.01515e-15
c1_269 xdut.vio_p xdut.xpad21.gp c=1.85132e-15
c1_267 xdut.vio_p xdut.xpad21.xlsgp.o1b c=1.08701e-15
c1_265 xdut.vio_p xdut.xpad21.gn c=1.67963e-15
c1_264 xdut.vio_p xdut.xpad21.xlsgn.o1b c=1.0949e-15
c1_261 xdut.vio_p xdut.xpad21.gnstrong c=3.77757e-15
c1_260 xdut.vio_p xdut.xpad21.gnweak c=1.13138e-14
c1_259 xdut.vio_p xdut.xpad21.gpweak c=2.04745e-14
c1_258 xdut.vio_p xdut.xpad21.gpstrong c=4.48984e-14
c1_257 xdut.vio_p xdut.xpad22.aoutbb c=1.19948e-15
c1_256 xdut.vio_p xdut.xpad22.dst2 c=1.52867e-15
c1_255 xdut.vio_p xdut.xpad22.aoutb c=2.67719e-15
c1_254 xdut.vio_p xdut.net2131 c=1.02691e-14
c1_252 xdut.vio_p xdut.xpad22.pub_ls c=1.62952e-15
c1_251 xdut.vio_p xdut.xpad22.xlspu.o1b c=1.07292e-15
c1_248 xdut.vio_p xdut.xpad22.xlspd.o1b c=1.08786e-15
c1_244 xdut.vio_p xdut.xpad22.ie_ls c=1.74548e-15
c1_242 xdut.vio_p xdut.xpad22.xlsie.o1b c=1.11085e-15
c1_241 xdut.vio_p xdut.xpad22.xlsie.o1 c=1.01402e-15
c1_240 xdut.vio_p xdut.xpad22.gp c=1.84988e-15
c1_239 xdut.vio_p xdut.xpad22.ds_ls c=1.4963e-15
c1_238 xdut.vio_p xdut.xpad22.dsb_ls c=3.35299e-15
c1_237 xdut.vio_p xdut.xpad22.xlsds.o1b c=1.14433e-15
c1_236 xdut.vio_p xdut.xpad22.xlsds.o1 c=1.01515e-15
c1_234 xdut.vio_p xdut.xpad22.gn c=1.68431e-15
c1_233 xdut.vio_p xdut.xpad22.xlsgn.o1b c=1.09796e-15
c1_230 xdut.vio_p xdut.xpad22.xlsgp.o1b c=1.09114e-15
c1_228 xdut.vio_p xdut.xpad22.gnstrong c=3.77719e-15
c1_227 xdut.vio_p xdut.xpad22.gnweak c=1.12989e-14
c1_226 xdut.vio_p xdut.xpad22.gpweak c=2.04614e-14
c1_225 xdut.vio_p xdut.xpad22.gpstrong c=4.48945e-14
c1_224 xdut.vio_p xdut.xpad23.aoutbb c=1.19948e-15
c1_223 xdut.vio_p xdut.xpad23.dst2 c=1.52783e-15
c1_222 xdut.vio_p xdut.xpad23.aoutb c=2.67719e-15
c1_221 xdut.vio_p xdut.net2132 c=1.02675e-14
c1_219 xdut.vio_p xdut.xpad23.pub_ls c=1.62949e-15
c1_218 xdut.vio_p xdut.xpad23.xlspu.o1b c=1.07292e-15
c1_214 xdut.vio_p xdut.xpad23.xlspd.o1b c=1.08786e-15
c1_211 xdut.vio_p xdut.xpad23.ie_ls c=1.74546e-15
c1_209 xdut.vio_p xdut.xpad23.xlsie.o1b c=1.11085e-15
c1_208 xdut.vio_p xdut.xpad23.xlsie.o1 c=1.01402e-15
c1_207 xdut.vio_p xdut.xpad23.gp c=1.84988e-15
c1_206 xdut.vio_p xdut.xpad23.ds_ls c=1.4963e-15
c1_205 xdut.vio_p xdut.xpad23.dsb_ls c=3.35306e-15
c1_204 xdut.vio_p xdut.xpad23.xlsds.o1b c=1.14071e-15
c1_203 xdut.vio_p xdut.xpad23.xlsds.o1 c=1.01515e-15
c1_201 xdut.vio_p xdut.xpad23.gn c=1.68237e-15
c1_200 xdut.vio_p xdut.xpad23.xlsgn.o1b c=1.09796e-15
c1_197 xdut.vio_p xdut.xpad23.xlsgp.o1b c=1.09114e-15
c1_195 xdut.vio_p xdut.xpad23.gnstrong c=3.77705e-15
c1_194 xdut.vio_p xdut.xpad23.gnweak c=1.12922e-14
c1_193 xdut.vio_p xdut.xpad23.gpweak c=2.04578e-14
c1_192 xdut.vio_p xdut.xpad23.gpstrong c=4.48913e-14
c1_191 xdut.vio_p xdut.xpad24.aoutbb c=1.19948e-15
c1_189 xdut.vio_p xdut.xpad24.dst2 c=1.52867e-15
c1_188 xdut.vio_p xdut.xpad24.aoutb c=2.67719e-15
c1_187 xdut.vio_p xdut.net3230 c=1.02686e-14
c1_186 xdut.vio_p xdut.xpad24.pub_ls c=1.62946e-15
c1_185 xdut.vio_p xdut.xpad24.xlspu.o1b c=1.07292e-15
c1_181 xdut.vio_p xdut.xpad24.xlspd.o1b c=1.08786e-15
c1_178 xdut.vio_p xdut.xpad24.ie_ls c=1.74546e-15
c1_176 xdut.vio_p xdut.xpad24.xlsie.o1b c=1.11085e-15
c1_175 xdut.vio_p xdut.xpad24.xlsie.o1 c=1.01402e-15
c1_174 xdut.vio_p xdut.xpad24.gp c=1.84988e-15
c1_172 xdut.vio_p xdut.xpad24.ds_ls c=1.49631e-15
c1_171 xdut.vio_p xdut.xpad24.dsb_ls c=3.35651e-15
c1_170 xdut.vio_p xdut.xpad24.xlsds.o1b c=1.14071e-15
c1_169 xdut.vio_p xdut.xpad24.xlsds.o1 c=1.01515e-15
c1_168 xdut.vio_p xdut.xpad24.xlsgp.o1b c=1.0927e-15
c1_165 xdut.vio_p xdut.xpad24.gn c=1.68247e-15
c1_164 xdut.vio_p xdut.xpad24.xlsgn.o1b c=1.09796e-15
c1_162 xdut.vio_p xdut.xpad24.gnstrong c=3.77776e-15
c1_161 xdut.vio_p xdut.xpad24.gnweak c=1.12855e-14
c1_160 xdut.vio_p xdut.xpad24.gpstrong c=4.48861e-14
c1_159 xdut.vio_p xdut.xpad24.gpweak c=2.04563e-14
c1_158 xdut.vio_p xdut.xi75.net_1 c=2.23522e-14
c1_157 xdut.vio_p xdut.xi75.net_2 c=2.46279e-14
c1_156 xdut.vio_p xdut.xpad20_gndio.net_0 c=2.23384e-14
c1_155 xdut.vio_p xdut.xpad20_gndio.net_2 c=2.46599e-14
c1_154 xdut.vio_p xdut.xi74.net_2 c=2.46421e-14
c1_153 xdut.vio_p xdut.xi74.net_1 c=2.23968e-14
c1_152 xdut.vio_p xdut.xpad19_vio.net_1 c=1.11111e-14
c1_151 xdut.vio_p xdut.xpad19_vio.net_2 c=1.10024e-14
c1_138 xdut.vio_p xdut.xpad13.dst2 c=1.56103e-15
c1_137 xdut.vio_p xdut.xpad13.aoutb c=2.71862e-15
c1_136 xdut.vio_p xdut.net3138 c=1.02048e-14
c1_135 xdut.vio_p xdut.xpad13.gnstrong c=3.7919e-15
c1_134 xdut.vio_p xdut.xpad13.gpstrong c=4.49263e-14
c1_133 xdut.vio_p xdut.xpad13.gpweak c=2.04925e-14
c1_131 xdut.vio_p xdut.xpad13.gn c=1.69282e-15
c1_130 xdut.vio_p xdut.xpad13.xlsgn.o1b c=1.08878e-15
c1_128 xdut.vio_p xdut.xpad13.gnweak c=1.11906e-14
c1_127 xdut.vio_p xdut.xpad13.gp c=1.86861e-15
c1_125 xdut.vio_p xdut.xpad13.xlsgp.o1b c=1.08087e-15
c1_123 xdut.vio_p xdut.xpad13.ds_ls c=1.51151e-15
c1_122 xdut.vio_p xdut.xpad13.dsb_ls c=3.41026e-15
c1_121 xdut.vio_p xdut.xpad13.xlsds.o1b c=1.12985e-15
c1_120 xdut.vio_p xdut.xpad13.xlsds.o1 c=1.00701e-15
c1_119 xdut.vio_p xdut.xpad13.xlsie.o1 c=1.00531e-15
c1_116 xdut.vio_p xdut.xpad13.ie_ls c=1.76196e-15
c1_114 xdut.vio_p xdut.xpad13.xlsie.o1b c=1.09966e-15
c1_112 xdut.vio_p xdut.xpad13.pub_ls c=1.64434e-15
c1_111 xdut.vio_p xdut.xpad13.xlspu.o1b c=1.08452e-15
c1_109 xdut.vio_p xdut.xpad13.xlspd.o1b c=1.08282e-15
c1_106 xdut.vio_p xdut.xpad13.aoutbb c=1.21787e-15
c1_105 xdut.vio_p xdut.xpad14.gnstrong c=3.79192e-15
c1_104 xdut.vio_p xdut.xpad14.gnweak c=1.1199e-14
c1_103 xdut.vio_p xdut.xpad14.gpstrong c=4.49268e-14
c1_102 xdut.vio_p xdut.xpad14.gpweak c=2.04902e-14
c1_100 xdut.vio_p xdut.xpad14.gn c=1.69274e-15
c1_99 xdut.vio_p xdut.xpad14.xlsgn.o1b c=1.08878e-15
c1_97 xdut.vio_p xdut.xpad14.xlsgp.o1b c=1.07886e-15
c1_95 xdut.vio_p xdut.xpad14.gp c=1.86871e-15
c1_93 xdut.vio_p xdut.xpad14.ds_ls c=1.5089e-15
c1_92 xdut.vio_p xdut.xpad14.dsb_ls c=3.41026e-15
c1_91 xdut.vio_p xdut.xpad14.xlsds.o1b c=1.13374e-15
c1_90 xdut.vio_p xdut.xpad14.xlsds.o1 c=1.00701e-15
c1_89 xdut.vio_p xdut.xpad14.ie_ls c=1.76026e-15
c1_87 xdut.vio_p xdut.xpad14.xlsie.o1b c=1.09966e-15
c1_86 xdut.vio_p xdut.xpad14.xlsie.o1 c=1.00531e-15
c1_85 xdut.vio_p xdut.xpad14.pub_ls c=1.64418e-15
c1_84 xdut.vio_p xdut.xpad14.xlspu.o1b c=1.07927e-15
c1_80 xdut.vio_p xdut.xpad14.xlspd.o1b c=1.08282e-15
c1_77 xdut.vio_p xdut.xpad14.aoutbb c=1.21824e-15
c1_75 xdut.vio_p xdut.xpad14.aoutb c=2.71421e-15
c1_74 xdut.vio_p xdut.xpad14.dst2 c=1.56072e-15
c1_73 xdut.vio_p xdut.net2136 c=1.02896e-14
c1_72 xdut.vio_p xdut.xpad15.gnstrong c=3.79192e-15
c1_71 xdut.vio_p xdut.xpad15.gnweak c=1.11919e-14
c1_70 xdut.vio_p xdut.xpad15.gpstrong c=4.49266e-14
c1_69 xdut.vio_p xdut.xpad15.gpweak c=2.04908e-14
c1_67 xdut.vio_p xdut.xpad15.gn c=1.69274e-15
c1_66 xdut.vio_p xdut.xpad15.xlsgn.o1b c=1.08878e-15
c1_64 xdut.vio_p xdut.xpad15.xlsgp.o1b c=1.07886e-15
c1_62 xdut.vio_p xdut.xpad15.gp c=1.86871e-15
c1_60 xdut.vio_p xdut.xpad15.ds_ls c=1.5089e-15
c1_59 xdut.vio_p xdut.xpad15.dsb_ls c=3.41019e-15
c1_58 xdut.vio_p xdut.xpad15.xlsds.o1b c=1.12984e-15
c1_57 xdut.vio_p xdut.xpad15.xlsds.o1 c=1.00701e-15
c1_56 xdut.vio_p xdut.xpad15.ie_ls c=1.7598e-15
c1_54 xdut.vio_p xdut.xpad15.xlsie.o1b c=1.09966e-15
c1_53 xdut.vio_p xdut.xpad15.xlsie.o1 c=1.00531e-15
c1_52 xdut.vio_p xdut.xpad15.pub_ls c=1.64424e-15
c1_51 xdut.vio_p xdut.xpad15.xlspu.o1b c=1.07927e-15
c1_47 xdut.vio_p xdut.xpad15.xlspd.o1b c=1.08282e-15
c1_44 xdut.vio_p xdut.xpad15.aoutbb c=1.21817e-15
c1_42 xdut.vio_p xdut.xpad15.aoutb c=2.71271e-15
c1_41 xdut.vio_p xdut.xpad15.dst2 c=1.56061e-15
c1_40 xdut.vio_p xdut.net2139 c=1.0309e-14
c1_39 xdut.vio_p xdut.xpad16.gnstrong c=3.79192e-15
c1_38 xdut.vio_p xdut.xpad16.gnweak c=1.11833e-14
c1_37 xdut.vio_p xdut.xpad16.gpstrong c=4.49262e-14
c1_36 xdut.vio_p xdut.xpad16.gpweak c=2.04858e-14
c1_34 xdut.vio_p xdut.xpad16.gn c=1.69282e-15
c1_33 xdut.vio_p xdut.xpad16.xlsgn.o1b c=1.08879e-15
c1_31 xdut.vio_p xdut.xpad16.xlsgp.o1b c=1.07888e-15
c1_29 xdut.vio_p xdut.xpad16.gp c=1.86864e-15
c1_27 xdut.vio_p xdut.xpad16.ds_ls c=1.51202e-15
c1_26 xdut.vio_p xdut.xpad16.dsb_ls c=3.41026e-15
c1_25 xdut.vio_p xdut.xpad16.xlsds.o1b c=1.12984e-15
c1_24 xdut.vio_p xdut.xpad16.xlsds.o1 c=1.00701e-15
c1_23 xdut.vio_p xdut.xpad16.ie_ls c=1.76025e-15
c1_21 xdut.vio_p xdut.xpad16.xlsie.o1b c=1.09969e-15
c1_20 xdut.vio_p xdut.xpad16.xlsie.o1 c=1.00524e-15
c1_19 xdut.vio_p xdut.xpad16.pub_ls c=1.64432e-15
c1_18 xdut.vio_p xdut.xpad16.xlspu.o1b c=1.0801e-15
c1_14 xdut.vio_p xdut.xpad16.xlspd.o1b c=1.08285e-15
c1_11 xdut.vio_p xdut.xpad16.aoutbb c=1.21873e-15
c1_10 xdut.vio_p xdut.resb_p c=2.45261e-13
c1_9 xdut.vio_p xdut.tmode_p c=2.45068e-13
c1_8 xdut.vio_p xdut.intb_p c=2.44426e-13
c1_7 xdut.vio_p xdut.dab_p c=2.45264e-13
c1_6 xdut.vio_p xdut.syncb_p c=2.45253e-13
c1_5 xdut.vio_p xdut.bfwb_p c=2.45245e-13
c1_4 xdut.vio_p xdut.csb_p c=2.45352e-13
c1_3 xdut.vio_p xdut.miso_p c=2.45171e-13
c1_2 xdut.vio_p xdut.mosi_p c=2.45494e-13
c1_1 xdut.vio_p xdut.sck_p c=2.45557e-13
cg419_1 xdut.rfc_oe 0 c=2.39152e-15
c647837_5 xdut.xpad1.pub xdut.xpad1.pubb c=1.01319e-15
c654_6 xdut.xpad1.aoutb xdut.net2456 c=1.35191e-15
c653_4 xdut.net2456 xdut.xpad1.pd_ls c=1.08268e-15
c649_4 xdut.xpad1.xlspu.o1b xdut.xpad1.xlspu.o1 c=1.45527e-15
c646_3 xdut.xpad1.xlspd.o1b xdut.xpad1.xlspd.o1 c=1.45401e-15
c643_3 xdut.xpad1.pd_ls xdut.xpad1.net424 c=1.01001e-15
c40899_1 xdut.xana.xdsi_ch1<1>.xrx.xflt3.inp_1 xdut.xana.xdsi_ch1<1>.xrx.net899 c=2.64056e-15
cg379_3 xdut.atst_rx<1> 0 c=2.18931e-15
c379_2 xdut.atst_rx<1> xdut.dsi_idac<5> c=3.44345e-15
cg369_3 xdut.dsi_idac<7> 0 c=2.02845e-15
c369_1 xdut.dsi_idac<7> xdut.dsi_idac<6> c=1.48661e-14
cg368_1 xdut.dsi_idac<8> 0 c=3.0705e-15
cg367_2 xdut.dsi_idac<5> 0 c=1.29569e-15
c367_1 xdut.dsi_idac<5> xdut.dsi_idac<6> c=1.59039e-14
cg366_1 xdut.dsi_idac<9> 0 c=3.26785e-15
cg42942_9 xdut.xana.xotpmux.vpp_div 0 c=1.0593e-15
c42942_8 xdut.xana.xotpmux.vpp_div xdut.xana.xotpmux.xsw3.net28 c=1.22899e-15
c42942_5 xdut.xana.xotpmux.vpp_div xdut.xana.xotpmux.net285 c=3.3973e-15
c42942_4 xdut.xana.xotpmux.vpp_div xdut.xana.xotpmux.net281 c=3.38107e-15
c42941_3 xdut.xana.xotpmux.xsw3.net28 xdut.xana.xotpmux.xsw3.enb_int c=1.41887e-15
c42940_3 xdut.xana.xotpmux.xsw3.en_int xdut.xana.xotpmux.xsw3.enb_int c=1.11856e-15
c42936_2 xdut.xana.xotpmux.xls<5>.ls_an xdut.xana.xotpmux.xls<5>.ls_a c=1.61679e-15
c42930_3 xdut.xana.xotpmux.xls<1>.ls_an xdut.xana.xotpmux.xls<1>.ls_a c=1.61772e-15
c42927_2 xdut.xana.xotpmux.xls<0>.ls_an xdut.xana.xotpmux.xls<0>.ls_a c=1.61324e-15
cg42920_13 xdut.xana.xotpmux.atst_otp_5v<0> 0 c=1.13839e-15
c42920_12 xdut.xana.xotpmux.atst_otp_5v<0> xdut.xana.xotpmux.atst_otp_5v<1> c=4.95679e-15
c42916_2 xdut.xana.xotpmux.xls<2>.ls_an xdut.xana.xotpmux.xls<2>.ls_a c=1.60546e-15
cg42915_14 xdut.xana.xotpmux.atst_otp_5v<1> 0 c=1.20564e-15
c42915_12 xdut.xana.xotpmux.atst_otp_5v<1> xdut.xana.xotpmux.atst_otp_5v<2> c=6.1643e-15
c42913_8 xdut.xana.xotpmux.atst_otp_5v<2> xdut.xana.xotpmux.atst_otp_5v<3> c=5.54995e-15
c42909_3 xdut.xana.xotpmux.net277 xdut.xana.xotpmux.net275 c=3.35353e-15
c42909_2 xdut.xana.xotpmux.net277 xdut.xana.xotpmux.net279 c=3.35181e-15
c42908_1 xdut.xana.xotpmux.net281 xdut.xana.xotpmux.net279 c=3.34943e-15
c42907_1 xdut.xana.xotpmux.net273 xdut.xana.xotpmux.net275 c=3.3535e-15
c42904_3 xdut.xana.xotpmux.xls<3>.ls_an xdut.xana.xotpmux.xls<3>.ls_a c=1.62587e-15
cg42899_2 xdut.xana.xotpmux.vbn1 0 c=3.49066e-15
c42899_1 xdut.xana.xotpmux.vbn1 xdut.xana.xotpmux.dm11 c=1.14304e-14
cg42895_5 xdut.xana.xotpmux.vbn 0 c=1.25702e-15
c42895_4 xdut.xana.xotpmux.vbn xdut.xana.xotpmux.dm1 c=3.13541e-14
c42894_2 xdut.xana.xotpmux.xls<4>.ls_an xdut.xana.xotpmux.xls<4>.ls_a c=1.617e-15
cg42891_4 xdut.xana.xotpmux.dm1 0 c=6.72472e-15
cg42890_8 xdut.xana.xotpmux.atst_otp_5v<4> 0 c=9.8867e-15
cg42889_1 xdut.xana.xotpmux.dm11 0 c=5.42946e-15
cg42888_1 xdut.xana.xotpmux.net372 0 c=1.71696e-15
c42874_4 xdut.xana.xotpmux.xsw0.en_int xdut.xana.xotpmux.xsw0.enb_int c=1.10505e-15
c42873_1 xdut.xana.xotpmux.xsw0.enb_int xdut.xana.xotpmux.xsw0.net28 c=1.41811e-15
cg42872_2 xdut.xana.xotpmux.vbg_int 0 c=1.60678e-15
c42872_1 xdut.xana.xotpmux.vbg_int xdut.xana.xotpmux.xsw0.net28 c=1.22901e-15
c42870_3 xdut.xana.xotpmux.xsw1.enb_int xdut.xana.xotpmux.xsw1.net28 c=1.41786e-15
c42870_2 xdut.xana.xotpmux.xsw1.enb_int xdut.xana.xotpmux.xsw1.en_int c=1.10524e-15
c42867_2 xdut.xana.xotpmux.xsw2.en_int xdut.xana.xotpmux.xsw2.enb_int c=1.1036e-15
c42866_1 xdut.xana.xotpmux.xsw2.enb_int xdut.xana.xotpmux.xsw2.net28 c=1.41781e-15
c760_4 xdut.xana.xi66.ls_a xdut.xana.xi66.xd2a_lvpart_inst.net012 c=1.64289e-15
cg732_1 xdut.xana.atst_otp<5> 0 c=1.36929e-15
cg731_1 xdut.xana.atst_otp<4> 0 c=1.33092e-15
cg730_1 xdut.xana.atst_otp<3> 0 c=1.43911e-15
cg729_1 xdut.xana.atst_otp<2> 0 c=1.43379e-15
cg728_1 xdut.xana.atst_otp<1> 0 c=1.38256e-15
cg727_1 xdut.xana.atst_otp<0> 0 c=1.43414e-15
c648254_10 xdut.xpad21.xggp.o1 xdut.xpad21.i1b c=1.0459e-15
c648253_16 xdut.xpad21.ib xdut.xpad21.ibb c=1.56704e-15
c648253_6 xdut.xpad21.ib xdut.xpad21.oebb c=1.02275e-15
c648246_2 xdut.xpad21.cb xdut.xpad21.aoutbb c=1.15353e-15
c648240_5 xdut.xpad21.pub xdut.xpad21.pubb c=1.01214e-15
c648236_1 xdut.xpad21.gpesd xdut.miso_p c=1.28551e-14
c648235_1 xdut.xpad21.gnesd xdut.miso_p c=3.66384e-14
c648213_7 xdut.xpad21.oeb xdut.xpad21.oebb c=1.77425e-15
c648210_4 xdut.xpad21.xggn.o1 xdut.xpad21.i2b c=1.04711e-15
c587_16 xdut.xpad21.aoutbb xdut.xpad21.aoutb c=1.26454e-15
c587_6 xdut.xpad21.aoutbb xdut.xpad21.ie_ls c=2.0607e-15
c585_7 xdut.xpad21.aoutb xdut.net2130 c=1.35154e-15
c585_3 xdut.xpad21.aoutb xdut.xpad21.ie_ls c=1.79857e-15
c584_7 xdut.net2130 xdut.xpad21.pd_ls c=1.61023e-15
c584_4 xdut.net2130 xdut.xpad21.net424 c=2.10236e-15
c581_6 xdut.xpad21.xlspu.o1b xdut.xpad21.xlspu.o1 c=1.45181e-15
c579_7 xdut.xpad21.xlspd.o1b xdut.xpad21.xlspd.o1 c=1.45051e-15
c572_1 xdut.xpad21.xlsie.o1b xdut.xpad21.xlsie.o1 c=1.47131e-15
c570_4 xdut.xpad21.ds_ls xdut.xpad21.gnstrong c=1.43916e-15
c569_1 xdut.xpad21.dsb_ls xdut.xpad21.gpstrong c=1.13924e-15
c568_4 xdut.xpad21.xlsds.o1b xdut.xpad21.xlsds.o1 c=1.50888e-15
c566_10 xdut.xpad21.gp xdut.xpad21.xlsgp.o1b c=1.504e-15
c566_2 xdut.xpad21.gp xdut.xpad21.gpweak c=1.48582e-15
c564_3 xdut.xpad21.xlsgp.o1b xdut.xpad21.xlsgp.o1 c=1.44243e-15
c562_1 xdut.xpad21.gn xdut.xpad21.gnweak c=1.44771e-15
c561_3 xdut.xpad21.xlsgn.o1b xdut.xpad21.xlsgn.o1 c=1.44568e-15
c558_4 xdut.xpad21.gnstrong xdut.xpad21.gnweak c=1.59367e-15
c558_1 xdut.xpad21.gnstrong xdut.miso_p c=6.12159e-15
c557_3 xdut.xpad21.gnweak xdut.xpad21.gpweak c=7.47066e-15
c557_1 xdut.xpad21.gnweak xdut.miso_p c=2.35885e-15
c556_2 xdut.xpad21.gpweak xdut.xpad21.gpstrong c=2.79531e-15
c556_1 xdut.xpad21.gpweak xdut.miso_p c=7.44607e-15
c555_1 xdut.xpad21.gpstrong xdut.miso_p c=1.98071e-14
cg14_1 xdut.miso_p 0 c=4.31558e-14
cg43901_5 xdut.xana.xsup.xvddreg.xvddreg.net326 0 c=1.05919e-14
cg43896_12 xdut.xana.xsup.xvddreg.xvddreg.gate 0 c=1.58576e-14
cg43895_4 xdut.xana.xsup.xvddreg.xvddreg.vref_flt 0 c=3.17449e-14
cg43894_5 xdut.xana.xsup.xvddreg.xvddreg.gp1 0 c=1.68457e-15
cg43892_5 xdut.xana.xsup.xvddreg.xvddreg.vfbi 0 c=1.77162e-14
cg43888_4 xdut.xana.xsup.xvddreg.xvddreg.net311 0 c=5.08531e-14
cg43883_1 xdut.xana.xsup.xvddreg.xvddreg.vs_cl 0 c=2.76926e-15
cg43881_4 xdut.xana.xsup.xvccreg.xreg.nbl1 0 c=3.00205e-14
c43878_4 xdut.xana.xsup.xvddreg.rdiv<9> xdut.xana.xsup.xvddreg.rdiv<10> c=1.07871e-15
c43877_7 xdut.xana.xsup.xvddreg.rdiv<8> xdut.xana.xsup.xvddreg.rdiv<7> c=1.07852e-15
c43875_8 xdut.xana.xsup.xvddreg.rdiv<6> xdut.xana.xsup.xvddreg.rdiv<5> c=1.0783e-15
c43873_6 xdut.xana.xsup.xvddreg.rdiv<4> xdut.xana.xsup.xvddreg.rdiv<3> c=1.07863e-15
c43871_4 xdut.xana.xsup.xvddreg.rdiv<39> xdut.xana.xsup.xvddreg.rdiv<38> c=1.07867e-15
c43871_1 xdut.xana.xsup.xvddreg.rdiv<39> xdut.xana.xsup.xvddreg.net153 c=1.00393e-15
c43869_4 xdut.xana.xsup.xvddreg.rdiv<37> xdut.xana.xsup.xvddreg.rdiv<36> c=1.07872e-15
c43867_2 xdut.xana.xsup.xvddreg.rdiv<35> xdut.xana.xsup.xvddreg.rdiv<34> c=1.07797e-15
c43865_2 xdut.xana.xsup.xvddreg.rdiv<32> xdut.xana.xsup.xvddreg.rdiv<33> c=1.07808e-15
c43864_3 xdut.xana.xsup.xvddreg.rdiv<30> xdut.xana.xsup.xvddreg.rdiv<31> c=1.1144e-15
c43863_3 xdut.xana.xsup.xvddreg.rdiv<2> xdut.xana.xsup.xvddreg.rdiv<1> c=1.07804e-15
c43862_3 xdut.xana.xsup.xvddreg.rdiv<29> xdut.xana.xsup.xvddreg.rdiv<28> c=1.07797e-15
c43861_9 xdut.xana.xsup.xvddreg.rdiv<27> xdut.xana.xsup.xvddreg.rdiv<26> c=1.07872e-15
c43859_8 xdut.xana.xsup.xvddreg.rdiv<25> xdut.xana.xsup.xvddreg.rdiv<24> c=1.07802e-15
c43857_8 xdut.xana.xsup.xvddreg.rdiv<23> xdut.xana.xsup.xvddreg.rdiv<22> c=1.07856e-15
c43855_7 xdut.xana.xsup.xvddreg.rdiv<21> xdut.xana.xsup.xvddreg.rdiv<20> c=1.07856e-15
c43854_5 xdut.xana.xsup.xvddreg.rdiv<20> xdut.xana.xsup.xvddreg.rdiv<19> c=1.07857e-15
c43852_1 xdut.xana.xsup.xvddreg.rdiv<19> xdut.xana.xsup.xvddreg.net153 c=1.67802e-15
c43851_4 xdut.xana.xsup.xvddreg.rdiv<18> xdut.xana.xsup.xvddreg.rdiv<17> c=1.07861e-15
c43849_4 xdut.xana.xsup.xvddreg.rdiv<16> xdut.xana.xsup.xvddreg.rdiv<15> c=1.07869e-15
c43847_4 xdut.xana.xsup.xvddreg.rdiv<14> xdut.xana.xsup.xvddreg.rdiv<13> c=1.07809e-15
c43845_4 xdut.xana.xsup.xvddreg.rdiv<12> xdut.xana.xsup.xvddreg.rdiv<11> c=1.0783e-15
c43842_1 xdut.xana.xsup.xvddreg.xrdiv.net118 xdut.xana.xsup.xvddreg.net153 c=3.01238e-15
cg43827_10 xdut.xana.xsup.xvddreg.xcomp.net60 0 c=1.65366e-15
c43827_7 xdut.xana.xsup.xvddreg.xcomp.net60 xdut.xana.xsup.xvddreg.xcomp.nn6 c=1.86303e-15
c43827_5 xdut.xana.xsup.xvddreg.xcomp.net60 xdut.xana.xsup.xvddreg.vdd_uv_i c=1.41256e-15
c43826_14 xdut.xana.xsup.xvddreg.xcomp.enb xdut.xana.xsup.xvddreg.xcomp.nn4 c=3.32158e-15
cg43825_5 xdut.xana.xsup.xvddreg.net129 0 c=2.98676e-15
c43825_4 xdut.xana.xsup.xvddreg.net129 xdut.xana.xsup.xvddreg.rdiv<31> c=1.1302e-15
c43825_1 xdut.xana.xsup.xvddreg.net129 xdut.xana.xsup.xvddreg.iload_en c=1.32418e-15
cg43824_15 xdut.xana.xsup.xvddreg.xcomp.nn4 0 c=1.3524e-15
c43824_14 xdut.xana.xsup.xvddreg.xcomp.nn4 xdut.xana.xsup.xvddreg.xcomp.nn6 c=2.69376e-15
cg43823_13 xdut.xana.xsup.xvddreg.xcomp.nn6 0 c=1.534e-15
c43823_11 xdut.xana.xsup.xvddreg.xcomp.nn6 xdut.xana.xsup.xvddreg.xcomp.nnvc c=1.64682e-15
c43823_10 xdut.xana.xsup.xvddreg.xcomp.nn6 xdut.xana.xsup.xvddreg.vdd_uv_i c=1.19934e-15
cg43822_18 xdut.xana.xsup.xvddreg.ibn1u 0 c=6.69231e-15
cg43820_18 xdut.xana.xsup.xvddreg.xcomp.nnvc 0 c=4.84667e-14
cg43817_14 xdut.xana.xsup.xvddreg.vdd_uv_i 0 c=1.64519e-15
cg43812_8 xdut.xana.xsup.xvddreg.net224 0 c=5.80247e-15
c43810_6 xdut.xana.xsup.xvddreg.xcomp.nn2 xdut.xana.xsup.xvddreg.xcomp.nn1 c=2.47138e-15
c43810_5 xdut.xana.xsup.xvddreg.xcomp.nn2 xdut.xana.xsup.xvddreg.xcomp.nn3 c=3.53685e-15
c43810_2 xdut.xana.xsup.xvddreg.xcomp.nn2 xdut.xana.xsup.xvddreg.xcomp.inp c=3.33349e-15
cg43809_4 xdut.xana.xsup.xvddreg.xcomp.nn1 0 c=1.20841e-15
c43809_3 xdut.xana.xsup.xvddreg.xcomp.nn1 xdut.xana.xsup.xvddreg.xcomp.nn3 c=5.37965e-15
c43809_2 xdut.xana.xsup.xvddreg.xcomp.nn1 xdut.xana.xsup.xvddreg.vbg_int c=1.78979e-15
c43809_1 xdut.xana.xsup.xvddreg.xcomp.nn1 xdut.xana.xsup.xvddreg.xcomp.inp c=1.15341e-15
c43808_4 xdut.xana.xsup.xvddreg.xcomp.nn3 xdut.xana.xsup.xvddreg.vbg_int c=1.27389e-15
cg43805_7 xdut.xana.xsup.xvddreg.rdiv<31> 0 c=2.93682e-15
c43805_5 xdut.xana.xsup.xvddreg.rdiv<31> xdut.xana.xsup.xvddreg.rdiv<33> c=3.30612e-15
cg43804_5 xdut.xana.xsup.xvddreg.rdiv<28> 0 c=3.20501e-15
c43804_3 xdut.xana.xsup.xvddreg.rdiv<28> xdut.xana.xsup.xvddreg.net153 c=2.55989e-15
cg43803_5 xdut.xana.xsup.xvddreg.rdiv<33> 0 c=2.55093e-15
c43803_3 xdut.xana.xsup.xvddreg.rdiv<33> xdut.xana.xsup.xvddreg.net153 c=3.09208e-15
cg43800_3 xdut.xana.xsup.xvddreg.vbg_int 0 c=3.65387e-14
c43800_1 xdut.xana.xsup.xvddreg.vbg_int xdut.xana.xsup.xvddreg.xcomp.inp c=2.22759e-15
cg43799_4 xdut.xana.xsup.xvddreg.rdiv_en 0 c=1.75069e-15
c43799_1 xdut.xana.xsup.xvddreg.rdiv_en xdut.xana.xsup.xvddreg.iload_en c=1.47781e-15
cg43797_2 xdut.xana.xsup.xvddreg.net153 0 c=4.17642e-15
cg43796_1 xdut.xana.xsup.xvddreg.iload_en 0 c=1.33348e-15
c43793_1 xdut.xana.xsup.xvddreg.divh xdut.xana.xsup.xvddreg.divl c=1.80945e-15
cg222_1 xdut.xana.xsup.xvddreg.xvddreg.net339 0 c=3.50279e-14
cg44582_1 xdut.xana.xtmon.xtsens.net21 0 c=1.85195e-14
cg44573_8 xdut.xana.xtmon.xcomp2.nn1 0 c=1.2362e-15
c44573_6 xdut.xana.xtmon.xcomp2.nn1 xdut.xana.xtmon.v_tsens_i c=1.64356e-15
c44573_4 xdut.xana.xtmon.xcomp2.nn1 xdut.xana.xtmon.xcomp2.inp c=1.13031e-15
c44573_2 xdut.xana.xtmon.xcomp2.nn1 xdut.xana.xtmon.xcomp2.nn3 c=5.40051e-15
c44573_1 xdut.xana.xtmon.xcomp2.nn1 xdut.xana.xtmon.xcomp2.nn2 c=2.48098e-15
cg44567_12 xdut.xana.xtmon.xcomp1.nn1 0 c=1.22773e-15
c44567_10 xdut.xana.xtmon.xcomp1.nn1 xdut.xana.xtmon.v_tsens_i c=1.64241e-15
c44567_5 xdut.xana.xtmon.xcomp1.nn1 xdut.xana.xtmon.xcomp1.inp c=1.13179e-15
c44567_2 xdut.xana.xtmon.xcomp1.nn1 xdut.xana.xtmon.xcomp1.nn3 c=5.39888e-15
c44567_1 xdut.xana.xtmon.xcomp1.nn1 xdut.xana.xtmon.xcomp1.nn2 c=2.47784e-15
c44557_3 xdut.xana.xtmon.xls1<0>.ls_an xdut.xana.xtmon.xls1<0>.ls_a c=1.59657e-15
c44555_2 xdut.xana.xtmon.xls1<1>.ls_an xdut.xana.xtmon.xls1<1>.ls_a c=1.5966e-15
cg44550_11 xdut.xana.xtmon.adj_ot_5v<0> 0 c=1.2028e-15
c44550_6 xdut.xana.xtmon.adj_ot_5v<0> xdut.xana.xtmon.adj_ot_5v<1> c=1.41885e-15
c44550_4 xdut.xana.xtmon.adj_ot_5v<0> xdut.xana.xtmon.net740 c=1.91651e-15
c44550_1 xdut.xana.xtmon.adj_ot_5v<0> xdut.xana.xtmon.net745 c=1.4505e-15
c44545_1 xdut.xana.xtmon.xls4<0>.ls_an xdut.xana.xtmon.xls4<0>.ls_a c=1.59154e-15
c44543_2 xdut.xana.xtmon.xls4<1>.ls_an xdut.xana.xtmon.xls4<1>.ls_a c=1.59307e-15
cg44535_30 xdut.xana.xtmon.v_tsens_i 0 c=8.52148e-15
c44535_14 xdut.xana.xtmon.v_tsens_i xdut.xana.xtmon.xcomp2.inp c=2.22818e-15
c44535_11 xdut.xana.xtmon.v_tsens_i xdut.xana.xtmon.xcomp2.nn3 c=1.26915e-15
c44535_7 xdut.xana.xtmon.v_tsens_i xdut.xana.xtmon.xcomp1.inp c=2.22804e-15
c44535_6 xdut.xana.xtmon.v_tsens_i xdut.xana.xtmon.net687 c=1.06801e-15
c44535_3 xdut.xana.xtmon.v_tsens_i xdut.xana.xtmon.xcomp1.nn3 c=1.27045e-15
cg44526_5 xdut.xana.xtmon.adj_ot_5v<1> 0 c=2.85102e-15
cg44524_10 xdut.xana.xtmon.net664 0 c=1.10349e-15
c44523_8 xdut.xana.xtmon.net666 xdut.xana.xtmon.otwarn_5v c=1.73714e-15
c44523_7 xdut.xana.xtmon.net666 xdut.xana.xtmon.xcomp1.nn6 c=1.00199e-15
c44523_1 xdut.xana.xtmon.net666 xdut.xana.xtmon.xcomp1.net60 c=1.43941e-15
c44522_10 xdut.xana.xtmon.xcomp1.enb xdut.xana.xtmon.otwarn_5v c=1.46461e-15
c44522_5 xdut.xana.xtmon.xcomp1.enb xdut.xana.xtmon.xcomp1.nn4 c=3.32895e-15
cg44519_5 xdut.xana.ln_tmon.n_349 0 c=1.95391e-15
c44519_4 xdut.xana.ln_tmon.n_349 xdut.xana.xtmon.vref_ot_on c=3.33039e-15
c44519_2 xdut.xana.ln_tmon.n_349 xdut.xana.ln_tmon.n_341 c=3.35932e-15
cg44518_25 xdut.xana.xtmon.vref_ot_on 0 c=2.43745e-15
c44518_24 xdut.xana.xtmon.vref_ot_on xdut.xana.xtmon.net733 c=3.62473e-15
cg44517_3 xdut.xana.xtmon.net733 0 c=1.939e-15
c44517_2 xdut.xana.xtmon.net733 xdut.xana.ln_tmon.n_327 c=3.30028e-15
cg44516_5 xdut.xana.ln_tmon.n_346 0 c=1.6922e-15
c44516_4 xdut.xana.ln_tmon.n_346 xdut.xana.ln_tmon.n_345 c=3.29113e-15
c44516_2 xdut.xana.ln_tmon.n_346 xdut.xana.ln_tmon.n_342 c=3.35498e-15
cg44515_4 xdut.xana.ln_tmon.n_345 0 c=2.01551e-15
c44515_1 xdut.xana.ln_tmon.n_345 xdut.xana.ln_tmon.n_329 c=3.34115e-15
cg44514_4 xdut.xana.ln_tmon.n_344 0 c=2.08029e-15
c44514_3 xdut.xana.ln_tmon.n_344 xdut.xana.ln_tmon.n_340 c=3.34315e-15
c44514_1 xdut.xana.ln_tmon.n_344 xdut.xana.ln_tmon.n_329 c=3.2909e-15
cg44513_4 xdut.xana.ln_tmon.n_343 0 c=1.67118e-15
c44513_3 xdut.xana.ln_tmon.n_343 xdut.xana.ln_tmon.n_342 c=3.29988e-15
c44513_1 xdut.xana.ln_tmon.n_343 xdut.xana.ln_tmon.n_335 c=3.3643e-15
cg44512_2 xdut.xana.ln_tmon.n_342 0 c=1.75409e-15
cg44511_3 xdut.xana.ln_tmon.n_341 0 c=1.66758e-15
c44511_2 xdut.xana.ln_tmon.n_341 xdut.xana.ln_tmon.n_331 c=3.29293e-15
cg44510_4 xdut.xana.ln_tmon.n_340 0 c=1.5858e-15
c44510_3 xdut.xana.ln_tmon.n_340 xdut.xana.ln_tmon.n_339 c=3.31993e-15
cg44509_5 xdut.xana.ln_tmon.n_339 0 c=1.99135e-15
c44509_4 xdut.xana.ln_tmon.n_339 xdut.xana.ln_tmon.n_338 c=3.33396e-15
cg44508_3 xdut.xana.ln_tmon.n_338 0 c=1.45396e-15
c44508_2 xdut.xana.ln_tmon.n_338 xdut.xana.ln_tmon.n_334 c=3.32888e-15
cg44507_5 xdut.xana.ln_tmon.n_337 0 c=1.63029e-15
c44507_4 xdut.xana.ln_tmon.n_337 xdut.xana.ln_tmon.n_336 c=3.35477e-15
c44507_2 xdut.xana.ln_tmon.n_337 xdut.xana.ln_tmon.n_328 c=3.32428e-15
cg44506_3 xdut.xana.ln_tmon.n_336 0 c=1.71468e-15
c44506_2 xdut.xana.ln_tmon.n_336 xdut.xana.ln_tmon.n_335 c=3.31202e-15
cg44505_1 xdut.xana.ln_tmon.n_335 0 c=1.74347e-15
cg44504_3 xdut.xana.ln_tmon.n_334 0 c=1.89566e-15
c44504_2 xdut.xana.ln_tmon.n_334 xdut.xana.ln_tmon.n_333 c=3.33668e-15
cg44503_3 xdut.xana.ln_tmon.n_333 0 c=1.55485e-15
c44503_2 xdut.xana.ln_tmon.n_333 xdut.xana.ln_tmon.n_332 c=3.32311e-15
cg44502_4 xdut.xana.ln_tmon.n_332 0 c=1.96211e-15
c44502_2 xdut.xana.ln_tmon.n_332 xdut.xana.ln_tmon.n_330 c=3.3105e-15
cg44501_2 xdut.xana.ln_tmon.n_331 0 c=2.01612e-15
c44501_1 xdut.xana.ln_tmon.n_331 xdut.xana.ln_tmon.n_330 c=3.3517e-15
cg44500_1 xdut.xana.ln_tmon.n_330 0 c=1.59704e-15
cg44499_1 xdut.xana.ln_tmon.n_329 0 c=1.65427e-15
cg44498_1 xdut.xana.ln_tmon.n_328 0 c=1.82085e-15
cg44497_3 xdut.xana.ln_tmon.n_327 0 c=1.89085e-15
c44497_1 xdut.xana.ln_tmon.n_327 xdut.xana.xtmon.vref_warn_on c=3.35738e-15
cg44496_4 xdut.xana.ln_tmon.n_326 0 c=1.90091e-15
c44496_2 xdut.xana.ln_tmon.n_326 xdut.xana.xtmon.vref_warn_on c=3.31097e-15
c44496_1 xdut.xana.ln_tmon.n_326 xdut.xana.xtmon.vref_warn_off c=3.32441e-15
cg44495_4 xdut.xana.xtmon.net766 0 c=1.88387e-15
c44495_3 xdut.xana.xtmon.net766 xdut.xana.xtmon.vref_warn_off c=3.35799e-15
c44495_2 xdut.xana.xtmon.net766 xdut.xana.xtmon.net740 c=3.35794e-15
cg44494_7 xdut.xana.xtmon.vref_warn_on 0 c=8.49296e-15
c44494_6 xdut.xana.xtmon.vref_warn_on xdut.xana.xtmon.vref_warn_off c=9.82789e-15
c44494_4 xdut.xana.xtmon.vref_warn_on xdut.xana.xtmon.net690 c=3.79298e-15
c44494_3 xdut.xana.xtmon.vref_warn_on xdut.xana.xtmon.net680 c=3.76789e-15
cg44493_5 xdut.xana.xtmon.vref_warn_off 0 c=6.88619e-15
c44493_1 xdut.xana.xtmon.vref_warn_off xdut.xana.xtmon.net745 c=3.34347e-15
c44486_7 xdut.xana.xtmon.xsw1.net28 xdut.xana.xtmon.xsw1.enb_int c=1.41184e-15
c44486_4 xdut.xana.xtmon.xsw1.net28 xdut.xana.xtmon.net665 c=1.17849e-15
c44485_5 xdut.xana.xtmon.xsw1.en_int xdut.xana.xtmon.xsw1.enb_int c=1.06181e-15
cg44483_5 xdut.xana.xtmon.net699 0 c=3.3369e-15
cg44482_4 xdut.xana.xtmon.net544 0 c=2.72522e-15
cg44481_7 xdut.xana.xtmon.v_tsens 0 c=4.40493e-15
c44481_6 xdut.xana.xtmon.v_tsens xdut.xana.xtmon.net665 c=1.34894e-15
c44481_5 xdut.xana.xtmon.v_tsens xdut.xana.xtmon.xsw2.net28 c=1.16679e-15
cg44480_7 xdut.xana.xtmon.net665 0 c=3.10575e-15
c44480_6 xdut.xana.xtmon.net665 xdut.xana.xtmon.xsw2.net28 c=2.31807e-15
c44479_3 xdut.xana.xtmon.xsw2.net28 xdut.xana.xtmon.xsw2.enb_int c=1.41059e-15
c44478_2 xdut.xana.xtmon.xsw2.en_int xdut.xana.xtmon.xsw2.enb_int c=1.06381e-15
cg44474_3 xdut.xana.xtmon.net740 0 c=3.40111e-15
c44474_1 xdut.xana.xtmon.net740 xdut.xana.xtmon.net745 c=9.04654e-15
cg44465_12 xdut.xana.xtmon.otwarn_5v 0 c=3.9983e-15
c44465_10 xdut.xana.xtmon.otwarn_5v xdut.xana.xtmon.net680 c=1.53331e-15
c44465_8 xdut.xana.xtmon.otwarn_5v xdut.xana.xtmon.net687 c=2.95273e-15
c44465_3 xdut.xana.xtmon.otwarn_5v xdut.xana.xtmon.xcomp1.net60 c=1.29389e-15
c44462_3 xdut.xana.xtmon.xcomp2.inp xdut.xana.xtmon.xcomp2.nn3 c=1.31056e-15
c44462_2 xdut.xana.xtmon.xcomp2.inp xdut.xana.xtmon.xcomp2.nn2 c=2.72707e-15
cg44461_6 xdut.xana.xtmon.net690 0 c=1.06155e-14
c44461_2 xdut.xana.xtmon.net690 xdut.xana.xtmon.net687 c=7.89958e-15
cg44460_4 xdut.xana.xtmon.xcomp2.nn4 0 c=1.30913e-15
c44458_2 xdut.xana.xtmon.xcomp2.nn3 xdut.xana.xtmon.xcomp2.nn2 c=3.6469e-15
cg44451_9 xdut.xana.xtmon.xcomp1.nn6 0 c=1.56992e-15
c44451_5 xdut.xana.xtmon.xcomp1.nn6 xdut.xana.xtmon.xcomp1.nn4 c=2.70697e-15
c44451_4 xdut.xana.xtmon.xcomp1.nn6 xdut.xana.xtmon.xcomp1.nnvc c=1.61741e-15
c44451_1 xdut.xana.xtmon.xcomp1.nn6 xdut.xana.xtmon.xcomp1.net60 c=1.88253e-15
cg44450_9 xdut.xana.xtmon.net680 0 c=5.62036e-15
c44450_7 xdut.xana.xtmon.net680 xdut.xana.xtmon.net687 c=1.30452e-14
c44449_2 xdut.xana.xtmon.xcomp1.inp xdut.xana.xtmon.xcomp1.nn3 c=1.29704e-15
c44449_1 xdut.xana.xtmon.xcomp1.inp xdut.xana.xtmon.xcomp1.nn2 c=2.7263e-15
cg44448_6 xdut.xana.xtmon.net687 0 c=6.00578e-15
cg44447_5 xdut.xana.xtmon.xcomp1.nn4 0 c=1.31181e-15
cg44446_4 xdut.xana.xtmon.xcomp1.nnvc 0 c=9.36336e-15
c44445_2 xdut.xana.xtmon.xcomp1.nn3 xdut.xana.xtmon.xcomp1.nn2 c=3.64464e-15
cg44443_1 xdut.xana.xtmon.xcomp1.net60 0 c=1.2205e-15
cg44442_1 xdut.xana.xtmon.net745 0 c=3.34959e-15
cg21108_11 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2652 0 c=3.04832e-15
cg21105_8 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2662 0 c=1.61722e-14
cg21098_1 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vpco 0 c=3.21683e-14
cg778_1 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vpnc1 0 c=7.86302e-15
cg42008_3 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.net2662 0 c=1.62064e-14
cg42001_1 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vpco 0 c=3.16201e-14
cg40990_10 xdut.xana.xdsi_ch1<1>.xrx.xhs_sup.mn_hv_lim_d 0 c=3.74775e-15
cg40919_1 xdut.xana.xdsi_ch1<1>.xrx.xhs_sup.nd_mncas 0 c=1.40594e-15
cg21685_2 xdut.xana.xdsi_ch1<1>.xrx.xhs_sup.mphv_reg_d 0 c=2.74294e-15
cg21684_1 xdut.xana.xdsi_ch1<1>.xrx.xhs_sup.vreg_ref 0 c=1.15406e-15
c42861_11 xdut.xana.xldo.xvref.sel_1 xdut.xana.xldo.xvref.xtg1.on1_n c=1.04416e-15
c42859_7 xdut.xana.xldo.xvref.sel_0 xdut.xana.xldo.xvref.xtg0.on1_n c=1.04429e-15
c42857_2 xdut.xana.xldo.xvref.xtg7.on1_n xdut.xana.xldo.xvref.sel_7 c=1.04491e-15
cg42856_11 xdut.xana.xldo.xvref.net30 0 c=3.51373e-15
c42856_9 xdut.xana.xldo.xvref.net30 xdut.xana.xldo.xvref.net34 c=5.91184e-15
c42855_2 xdut.xana.xldo.xvref.xtg6.on1_n xdut.xana.xldo.xvref.sel_6 c=1.0426e-15
cg42854_13 xdut.xana.xldo.xvref.net34 0 c=9.56031e-15
c42854_11 xdut.xana.xldo.xvref.net34 xdut.xana.xldo.xvref.net38 c=6.2964e-15
c42853_2 xdut.xana.xldo.xvref.xtg5.on1_n xdut.xana.xldo.xvref.sel_5 c=1.04158e-15
cg42852_13 xdut.xana.xldo.xvref.net38 0 c=3.69772e-15
c42852_11 xdut.xana.xldo.xvref.net38 xdut.xana.xldo.xvref.net42 c=5.76834e-15
c42851_2 xdut.xana.xldo.xvref.xtg4.on1_n xdut.xana.xldo.xvref.sel_4 c=1.04824e-15
cg42850_13 xdut.xana.xldo.xvref.net42 0 c=1.00879e-14
c42850_11 xdut.xana.xldo.xvref.net42 xdut.xana.xldo.xvref.net46 c=6.32181e-15
c42850_9 xdut.xana.xldo.xvref.net42 xdut.xana.xldo.xvref.net50 c=1.09918e-14
c42850_8 xdut.xana.xldo.xvref.net42 xdut.xana.xldo.xvref.net211 c=1.39946e-15
c42849_2 xdut.xana.xldo.xvref.xtg3.on1_n xdut.xana.xldo.xvref.sel_3 c=1.04558e-15
cg42848_12 xdut.xana.xldo.xvref.net46 0 c=3.98517e-15
c42848_10 xdut.xana.xldo.xvref.net46 xdut.xana.xldo.xvref.net50 c=5.73585e-15
c42847_1 xdut.xana.xldo.xvref.xtg2.on1_n xdut.xana.xldo.xvref.sel_2 c=1.04202e-15
cg42846_14 xdut.xana.xldo.xvref.net50 0 c=7.89272e-15
c42846_12 xdut.xana.xldo.xvref.net50 xdut.xana.xldo.xvref.net211 c=5.76276e-15
cg42844_11 xdut.xana.xldo.xvref.net211 0 c=7.74555e-15
c42844_8 xdut.xana.xldo.xvref.net211 xdut.xana.xldo.xvref.net212 c=1.72852e-14
cg42840_5 xdut.xana.ln_ldo.vref.n_226 0 c=3.34824e-15
c42840_3 xdut.xana.ln_ldo.vref.n_226 xdut.xana.ln_ldo.vref.n_222 c=5.70554e-15
c42840_1 xdut.xana.ln_ldo.vref.n_226 xdut.xana.ln_ldo.vref.n_220 c=5.6641e-15
cg42839_3 xdut.xana.xldo.xvref.net212 0 c=6.88607e-15
c42839_2 xdut.xana.xldo.xvref.net212 xdut.xana.ln_ldo.vref.n_223 c=5.69532e-15
cg42838_3 xdut.xana.ln_ldo.vref.n_223 0 c=3.29183e-15
c42838_2 xdut.xana.ln_ldo.vref.n_223 xdut.xana.ln_ldo.vref.n_222 c=5.72104e-15
cg42837_2 xdut.xana.ln_ldo.vref.n_222 0 c=3.19703e-15
cg42836_4 xdut.xana.ln_ldo.vref.n_221 0 c=3.64394e-15
c42836_3 xdut.xana.ln_ldo.vref.n_221 xdut.xana.ln_ldo.vref.n_220 c=5.68619e-15
c42836_2 xdut.xana.ln_ldo.vref.n_221 xdut.xana.ln_ldo.vref.n_219 c=5.65041e-15
cg42835_2 xdut.xana.ln_ldo.vref.n_220 0 c=3.34105e-15
cg42834_2 xdut.xana.ln_ldo.vref.n_219 0 c=3.68594e-15
c42834_1 xdut.xana.ln_ldo.vref.n_219 xdut.xana.ln_ldo.vref.n_218 c=5.68072e-15
cg42833_1 xdut.xana.ln_ldo.vref.n_218 0 c=4.03765e-15
cg42832_18 xdut.xana.xldo.xvref.bit<2> 0 c=1.47943e-15
c42832_17 xdut.xana.xldo.xvref.bit<2> xdut.xana.xldo.xvref.bit<1> c=4.55895e-15
c42832_10 xdut.xana.xldo.xvref.bit<2> xdut.xana.xldo.xvref.b1n c=1.06091e-15
cg42831_22 xdut.xana.xldo.xvref.bit<1> 0 c=1.4057e-15
c42831_21 xdut.xana.xldo.xvref.bit<1> xdut.xana.xldo.xvref.bit<0> c=4.47956e-15
c42831_12 xdut.xana.xldo.xvref.bit<1> xdut.xana.xldo.xvref.b2n c=1.06519e-15
c42831_10 xdut.xana.xldo.xvref.bit<1> xdut.xana.xldo.xvref.b0n c=1.06175e-15
cg42830_19 xdut.xana.xldo.xvref.bit<0> 0 c=1.23224e-15
c42830_13 xdut.xana.xldo.xvref.bit<0> xdut.xana.xldo.xvref.b1n c=1.55197e-15
cg42813_11 xdut.xana.xldo.xvref.b2n 0 c=1.64783e-15
c42813_10 xdut.xana.xldo.xvref.b2n xdut.xana.xldo.xvref.b1n c=4.74436e-15
cg42812_11 xdut.xana.xldo.xvref.b1n 0 c=1.55182e-15
c42812_10 xdut.xana.xldo.xvref.b1n xdut.xana.xldo.xvref.b0n c=4.64639e-15
cg42811_12 xdut.xana.xldo.xvref.b0n 0 c=1.41406e-15
cg42704_6 xdut.xana.xldo.xamp.cms 0 c=5.33694e-15
c42704_5 xdut.xana.xldo.xamp.cms xdut.xana.xldo.xamp.vpb c=2.42186e-15
c42704_4 xdut.xana.xldo.xamp.cms xdut.xana.xldo.xamp.gl c=1.66596e-15
c42704_1 xdut.xana.xldo.xamp.cms xdut.xana.xldo.xamp.gr c=1.64685e-15
cg42703_11 xdut.xana.xldo.s_cas2 0 c=2.11702e-14
c42703_10 xdut.xana.xldo.s_cas2 xdut.xana.xldo.s_cas1 c=9.84317e-15
c42703_8 xdut.xana.xldo.s_cas2 xdut.xana.xldo.net667 c=2.93426e-14
c42703_7 xdut.xana.xldo.s_cas2 xdut.xana.xldo.net637 c=5.03517e-15
c42703_5 xdut.xana.xldo.s_cas2 xdut.xana.xldo.vd_msen c=1.69185e-15
c42703_3 xdut.xana.xldo.s_cas2 xdut.xana.xldo.vdsi_fc c=5.32412e-15
c42703_1 xdut.xana.xldo.s_cas2 xdut.xana.xldo.vdsi_nbl c=1.81293e-14
cg42702_10 xdut.xana.xldo.s_cas1 0 c=1.82971e-14
c42702_6 xdut.xana.xldo.s_cas1 xdut.xana.xldo.net635 c=4.4482e-15
c42702_2 xdut.xana.xldo.s_cas1 xdut.xana.xldo.vbp_lim c=1.34968e-14
c42702_1 xdut.xana.xldo.s_cas1 xdut.xana.xldo.vdsi_nbl c=1.46378e-14
cg42692_9 xdut.xana.xldo.net636 0 c=1.84131e-14
c42692_4 xdut.xana.xldo.net636 xdut.xana.xldo.ota_out c=6.08681e-15
c42692_1 xdut.xana.xldo.net636 xdut.xana.xldo.vbp_lim c=2.08992e-15
cg42691_7 xdut.xana.xldo.net667 0 c=1.01388e-14
c42691_6 xdut.xana.xldo.net667 xdut.xana.xldo.net637 c=2.0467e-15
c42691_5 xdut.xana.xldo.net667 xdut.xana.xldo.vd_msen c=2.76099e-15
c42691_2 xdut.xana.xldo.net667 xdut.xana.xldo.vbp_lim c=4.37332e-15
c42691_1 xdut.xana.xldo.net667 xdut.xana.xldo.vdsi_nbl c=2.62794e-15
cg42690_2 xdut.xana.xldo.net634 0 c=1.45148e-14
c42690_1 xdut.xana.xldo.net634 xdut.xana.xldo.vdsi_fc c=3.5398e-15
c42686_2 xdut.xana.xldo.net635 xdut.xana.xldo.vbp_lim c=1.46901e-15
c42684_2 xdut.xana.xldo.net640 xdut.xana.xldo.vgsen c=4.37084e-15
cg42683_2 xdut.xana.xldo.vgsen 0 c=3.16394e-15
cg42669_4 xdut.xana.xldo.vd_msen 0 c=1.32175e-14
c42669_3 xdut.xana.xldo.vd_msen xdut.xana.xldo.ota_out c=2.67786e-15
c42658_4 xdut.xana.ln_ldo.n_456 xdut.xana.ln_ldo.n_447 c=4.80094e-15
c42658_2 xdut.xana.ln_ldo.n_456 xdut.xana.ln_ldo.n_441 c=4.80746e-15
c42657_3 xdut.xana.ln_ldo.n_455 xdut.xana.ln_ldo.n_449 c=4.81008e-15
c42657_2 xdut.xana.ln_ldo.n_455 xdut.xana.ln_ldo.n_447 c=4.79861e-15
c42656_3 xdut.xana.ln_ldo.n_454 xdut.xana.ln_ldo.n_449 c=4.98359e-15
c42656_2 xdut.xana.ln_ldo.n_454 xdut.xana.xldo.vdiv2 c=5.27763e-15
c42651_3 xdut.xana.ln_ldo.n_445 xdut.xana.ln_ldo.n_441 c=4.80142e-15
c42651_2 xdut.xana.ln_ldo.n_445 xdut.xana.ln_ldo.n_440 c=4.80393e-15
c42650_3 xdut.xana.ln_ldo.n_444 xdut.xana.ln_ldo.n_440 c=4.80243e-15
c42650_2 xdut.xana.ln_ldo.n_444 xdut.xana.ln_ldo.n_439 c=4.79543e-15
c42649_3 xdut.xana.ln_ldo.n_443 xdut.xana.ln_ldo.n_439 c=4.80256e-15
c42649_2 xdut.xana.ln_ldo.n_443 xdut.xana.ln_ldo.n_438 c=4.79545e-15
c42648_2 xdut.xana.ln_ldo.n_442 xdut.xana.ln_ldo.n_438 c=4.89324e-15
cg42643_3 xdut.xana.xldo.vd_m0 0 c=4.76179e-14
c42643_2 xdut.xana.xldo.vd_m0 xdut.xana.xldo.ota_out c=7.73706e-15
c42643_1 xdut.xana.xldo.vd_m0 xdut.xana.xldo.vs_m0 c=9.48047e-15
c42641_4 xdut.xana.xldo.xsw_atb.en_int xdut.xana.xldo.xsw_atb.enb_int c=1.11642e-15
c42640_3 xdut.xana.xldo.xsw_atb.enb_int xdut.xana.xldo.xsw_atb.net28 c=1.41543e-15
c42638_1 xdut.xana.xldo.xsw_atb.net28 xdut.xana.no_aout c=2.44379e-15
c42637_7 xdut.xana.xldo.xls2.ls_a xdut.xana.xldo.xls2.ls_an c=1.66871e-15
c42634_4 xdut.xana.xldo.xls1.ls_a xdut.xana.xldo.xls1.ls_an c=1.64914e-15
cg42633_2 xdut.xana.xldo.dm2 0 c=2.40549e-15
cg42620_7 xdut.xana.xldo.xamp.ena 0 c=2.22656e-15
c42620_6 xdut.xana.xldo.xamp.ena xdut.xana.xldo.xamp.dis_int c=2.89016e-15
c42620_4 xdut.xana.xldo.xamp.ena xdut.xana.xldo.xamp.vpb c=1.45524e-15
c42620_1 xdut.xana.xldo.xamp.ena xdut.xana.xldo.vdsi_off_5v c=3.01488e-15
cg42619_2 xdut.xana.xldo.xuvcomp.net60 0 c=1.57076e-15
c42618_6 xdut.xana.xldo.xamp.dis_int xdut.xana.xldo.xamp.vpb c=2.13239e-15
cg42617_5 xdut.xana.xldo.i5u_ota 0 c=5.36639e-15
cg42616_6 xdut.xana.xldo.xamp.vpb 0 c=5.10001e-15
c42616_4 xdut.xana.xldo.xamp.vpb xdut.xana.xldo.xamp.glm c=1.13193e-15
cg42615_4 xdut.xana.xldo.xamp.cmg 0 c=5.44371e-15
cg42613_4 xdut.xana.xldo.xamp.gl 0 c=6.99348e-15
c42613_3 xdut.xana.xldo.xamp.gl xdut.xana.xldo.xamp.glm c=1.19325e-15
c42613_1 xdut.xana.xldo.xamp.gl xdut.xana.xldo.xamp.gr c=4.8843e-15
cg42612_3 xdut.xana.xldo.xamp.glm 0 c=7.00426e-15
c42612_2 xdut.xana.xldo.xamp.glm xdut.xana.xldo.ota_out c=1.00598e-14
cg42611_7 xdut.xana.xldo.ota_out 0 c=1.80618e-13
c42611_6 xdut.xana.xldo.ota_out xdut.xana.xldo.xamp.gr c=1.11401e-15
c42611_3 xdut.xana.xldo.ota_out xdut.xana.xldo.vs_m0 c=7.85964e-15
c42611_2 xdut.xana.xldo.ota_out xdut.xana.xldo.vbp_lim c=1.62341e-15
cg42610_1 xdut.xana.xldo.xamp.gr 0 c=1.12962e-14
cg42605_4 xdut.xana.xldo.vdsi_off_5v 0 c=8.72636e-15
c42605_1 xdut.xana.xldo.vdsi_off_5v xdut.xana.xldo.vs_m0 c=3.10133e-15
cg42597_2 xdut.xana.xldo.vdsi_on_5v 0 c=2.34635e-15
c42597_1 xdut.xana.xldo.vdsi_on_5v xdut.xana.xldo.vdsi2atb_5v c=1.81183e-15
cg42596_2 xdut.xana.xldo.vdsi2atb_5v 0 c=1.98078e-15
cg234_4 xdut.xana.xldo.vdsi_fc 0 c=3.86631e-14
c234_3 xdut.xana.xldo.vdsi_fc xdut.xana.xldo.vs_m0 c=2.31828e-15
c234_1 xdut.xana.xldo.vdsi_fc xdut.xana.xldo.vdsi_nbl c=4.46081e-14
cg233_2 xdut.xana.xldo.vs_m0 0 c=3.57251e-14
c233_1 xdut.xana.xldo.vs_m0 xdut.xana.xldo.vdsi_nbl c=1.87466e-14
cg232_2 xdut.xana.xldo.vbp_lim 0 c=2.9813e-14
c232_1 xdut.xana.xldo.vbp_lim xdut.xana.xldo.vdsi_nbl c=1.02005e-15
cg215_1 xdut.xana.xldo.vdsi_nbl 0 c=5.80149e-14
c648150_7 xdut.xpad18.xggp.o1 xdut.xpad18.i1b c=1.04724e-15
c648149_12 xdut.xpad18.ib xdut.xpad18.ibb c=1.56795e-15
c648142_2 xdut.xpad18.cb xdut.xpad18.aoutbb c=1.15359e-15
c648140_1 xdut.xpad18.pdb xdut.rfc_pd c=1.02313e-15
c648136_6 xdut.xpad18.pub xdut.xpad18.pubb c=1.01336e-15
c648106_2 xdut.xpad18.xggn.o1 xdut.xpad18.i2b c=1.04479e-15
c648100_10 xdut.xpad17.xggp.o1 xdut.xpad17.i1b c=1.04724e-15
c648099_16 xdut.xpad17.ib xdut.xpad17.ibb c=1.56795e-15
c648099_7 xdut.xpad17.ib xdut.xpad17.oebb c=1.02598e-15
c648092_2 xdut.xpad17.cb xdut.xpad17.aoutbb c=1.15358e-15
c648090_2 xdut.xpad17.pdb xdut.bfwb_pd c=1.02313e-15
c648086_7 xdut.xpad17.pub xdut.xpad17.pubb c=1.01336e-15
c648082_1 xdut.xpad17.gpesd xdut.bfwb_p c=1.28537e-14
c648081_1 xdut.xpad17.gnesd xdut.bfwb_p c=3.66357e-14
c648059_8 xdut.xpad17.oeb xdut.xpad17.oebb c=1.76643e-15
c648056_4 xdut.xpad17.xggn.o1 xdut.xpad17.i2b c=1.04478e-15
c648050_10 xdut.xpad16.xggp.o1 xdut.xpad16.i1b c=1.04724e-15
c648049_16 xdut.xpad16.ib xdut.xpad16.ibb c=1.56795e-15
c648049_7 xdut.xpad16.ib xdut.xpad16.oebb c=1.02598e-15
c648042_1 xdut.xpad16.cb xdut.xpad16.aoutbb c=1.15359e-15
c648040_3 xdut.xpad16.pdb xdut.syncb_pd c=1.02313e-15
c648036_7 xdut.xpad16.pub xdut.xpad16.pubb c=1.01336e-15
c648032_1 xdut.xpad16.gpesd xdut.syncb_p c=1.28537e-14
c648031_1 xdut.xpad16.gnesd xdut.syncb_p c=3.66356e-14
c648009_8 xdut.xpad16.oeb xdut.xpad16.oebb c=1.76633e-15
c648006_4 xdut.xpad16.xggn.o1 xdut.xpad16.i2b c=1.04479e-15
c723_8 xdut.xpad16.aoutb xdut.net2135 c=1.35152e-15
c723_5 xdut.xpad16.aoutb xdut.xpad16.ie_ls c=1.79729e-15
c723_1 xdut.xpad16.aoutb xdut.xpad16.aoutbb c=1.26856e-15
c721_13 xdut.net2135 xdut.xpad16.net424 c=2.09532e-15
c721_4 xdut.net2135 xdut.xpad16.pd_ls c=1.61177e-15
c719_4 xdut.xpad17.gn xdut.xpad17.gnweak c=1.46155e-15
c718_7 xdut.xpad17.xlsgn.o1b xdut.xpad17.xlsgn.o1 c=1.44911e-15
c716_7 xdut.xpad17.gnstrong xdut.xpad17.gnweak c=1.60297e-15
c716_3 xdut.xpad17.gnstrong xdut.xpad17.ds_ls c=1.44798e-15
c716_1 xdut.xpad17.gnstrong xdut.bfwb_p c=6.11877e-15
c715_6 xdut.xpad17.gnweak xdut.xpad17.gpweak c=7.47388e-15
c715_1 xdut.xpad17.gnweak xdut.bfwb_p c=2.35173e-15
c714_5 xdut.xpad17.gpstrong xdut.xpad17.gpweak c=2.79484e-15
c714_2 xdut.xpad17.gpstrong xdut.xpad17.dsb_ls c=1.14378e-15
c714_1 xdut.xpad17.gpstrong xdut.bfwb_p c=1.98081e-14
c713_4 xdut.xpad17.gpweak xdut.xpad17.gp c=1.50031e-15
c713_1 xdut.xpad17.gpweak xdut.bfwb_p c=7.44805e-15
c712_5 xdut.xpad17.gp xdut.xpad17.xlsgp.o1b c=1.50251e-15
c710_5 xdut.xpad17.xlsgp.o1b xdut.xpad17.xlsgp.o1 c=1.44584e-15
c706_1 xdut.xpad17.xlsds.o1b xdut.xpad17.xlsds.o1 c=1.51279e-15
c704_4 xdut.xpad17.pd_ls xdut.net2134 c=1.60996e-15
c703_12 xdut.xpad17.ie_ls xdut.xpad17.aoutbb c=2.06082e-15
c703_3 xdut.xpad17.ie_ls xdut.xpad17.aoutb c=1.79729e-15
c701_4 xdut.xpad17.xlsie.o1b xdut.xpad17.xlsie.o1 c=1.47491e-15
c683_4 xdut.xpad17.aoutbb xdut.xpad17.aoutb c=1.26856e-15
c680_6 xdut.xpad17.xlspu.o1b xdut.xpad17.xlspu.o1 c=1.4552e-15
c677_2 xdut.xpad17.xlspd.o1b xdut.xpad17.xlspd.o1 c=1.45396e-15
c673_3 xdut.xpad17.aoutb xdut.net2134 c=1.35152e-15
c672_4 xdut.net2134 xdut.xpad17.net424 c=2.09433e-15
c662_3 xdut.xpad18.xlsgp.o1b xdut.xpad18.xlsgp.o1 c=1.44583e-15
c657_1 xdut.xpad18.xlsds.o1b xdut.xpad18.xlsds.o1 c=1.51279e-15
c638_8 xdut.xpad18.ie_ls xdut.xpad18.aoutbb c=2.06049e-15
c638_3 xdut.xpad18.ie_ls xdut.xpad18.aoutb c=1.79895e-15
c636_5 xdut.xpad18.xlsie.o1b xdut.xpad18.xlsie.o1 c=1.47491e-15
c634_2 xdut.xpad18.xlspu.o1 xdut.xpad18.xlspu.o1b c=1.4552e-15
c633_4 xdut.xpad18.pd_ls xdut.net2138 c=1.60996e-15
c631_4 xdut.xpad18.xlspd.o1b xdut.xpad18.xlspd.o1 c=1.45396e-15
c629_4 xdut.xpad18.aoutbb xdut.xpad18.aoutb c=1.26856e-15
c622_3 xdut.xpad18.aoutb xdut.net2138 c=1.35152e-15
c621_3 xdut.net2138 xdut.xpad18.net424 c=2.10726e-15
cg437_2 xdut.syncb_oe 0 c=2.94763e-15
c437_1 xdut.syncb_oe xdut.syncb_p c=1.2244e-15
cg436_3 xdut.syncb_i 0 c=2.89129e-15
c436_1 xdut.syncb_i xdut.syncb_p c=1.22536e-15
cg435_2 xdut.syncb_o 0 c=2.79305e-15
c435_1 xdut.syncb_o xdut.syncb_p c=1.222e-15
cg434_2 xdut.syncb_ie 0 c=2.91465e-15
c434_1 xdut.syncb_ie xdut.syncb_p c=1.22548e-15
cg433_2 xdut.syncb_pd 0 c=2.7671e-15
c433_1 xdut.syncb_pd xdut.syncb_p c=1.20141e-15
cg432_2 xdut.syncb_pu 0 c=2.6596e-15
c432_1 xdut.syncb_pu xdut.syncb_p c=1.20479e-15
cg430_2 xdut.bfwb_o 0 c=1.91632e-15
c430_1 xdut.bfwb_o xdut.bfwb_p c=1.39689e-15
cg429_2 xdut.bfwb_oe 0 c=2.96286e-15
c429_1 xdut.bfwb_oe xdut.bfwb_p c=1.22432e-15
cg428_3 xdut.bfwb_i 0 c=1.79812e-15
c428_1 xdut.bfwb_i xdut.bfwb_p c=1.44696e-15
cg427_3 xdut.bfwb_ie 0 c=1.73527e-15
c427_1 xdut.bfwb_ie xdut.bfwb_p c=1.42431e-15
cg426_3 xdut.bfwb_pd 0 c=1.50438e-15
c426_1 xdut.bfwb_pd xdut.bfwb_p c=1.3377e-15
cg422_2 xdut.bfwb_pu 0 c=2.29817e-15
c422_1 xdut.bfwb_pu xdut.bfwb_p c=1.3862e-15
cg418_1 xdut.rfc_o 0 c=2.76758e-15
cg417_1 xdut.rfc_pu 0 c=2.81984e-15
cg416_1 xdut.rfc_pd 0 c=2.88507e-15
cg415_2 xdut.rfc_ie 0 c=2.82066e-15
cg414_1 xdut.rfc_i 0 c=2.8819e-15
c55_8 xdut.xpad16.gnstrong xdut.xpad16.gnweak c=1.603e-15
c55_3 xdut.xpad16.gnstrong xdut.xpad16.ds_ls c=1.44818e-15
c55_1 xdut.xpad16.gnstrong xdut.syncb_p c=6.11877e-15
c54_8 xdut.xpad16.gnweak xdut.xpad16.gpweak c=7.47388e-15
c54_6 xdut.xpad16.gnweak xdut.xpad16.gn c=1.46058e-15
c54_1 xdut.xpad16.gnweak xdut.syncb_p c=2.35141e-15
c53_5 xdut.xpad16.gpstrong xdut.xpad16.gpweak c=2.79644e-15
c53_2 xdut.xpad16.gpstrong xdut.xpad16.dsb_ls c=1.14378e-15
c53_1 xdut.xpad16.gpstrong xdut.syncb_p c=1.98081e-14
c52_4 xdut.xpad16.gpweak xdut.xpad16.gp c=1.50031e-15
c52_1 xdut.xpad16.gpweak xdut.syncb_p c=7.44791e-15
c49_6 xdut.xpad16.xlsgn.o1b xdut.xpad16.xlsgn.o1 c=1.44911e-15
c47_7 xdut.xpad16.xlsgp.o1b xdut.xpad16.xlsgp.o1 c=1.44584e-15
c47_6 xdut.xpad16.xlsgp.o1b xdut.xpad16.gp c=1.50251e-15
c41_1 xdut.xpad16.xlsds.o1b xdut.xpad16.xlsds.o1 c=1.51279e-15
c39_1 xdut.xpad16.ie_ls xdut.xpad16.aoutbb c=2.06082e-15
c37_5 xdut.xpad16.xlsie.o1b xdut.xpad16.xlsie.o1 c=1.47491e-15
c34_5 xdut.xpad16.xlspu.o1b xdut.xpad16.xlspu.o1 c=1.4552e-15
c30_3 xdut.xpad16.xlspd.o1b xdut.xpad16.xlspd.o1 c=1.45396e-15
cg17_1 xdut.syncb_p 0 c=7.42525e-14
cg16_1 xdut.bfwb_p 0 c=4.3482e-14
c648000_10 xdut.xpad15.xggp.o1 xdut.xpad15.i1b c=1.04724e-15
c647999_15 xdut.xpad15.ib xdut.xpad15.ibb c=1.56795e-15
c647999_6 xdut.xpad15.ib xdut.xpad15.oebb c=1.02598e-15
c647992_1 xdut.xpad15.cb xdut.xpad15.aoutbb c=1.15359e-15
c647986_6 xdut.xpad15.pub xdut.xpad15.pubb c=1.01336e-15
c647982_1 xdut.xpad15.gpesd xdut.resb_p c=1.28537e-14
c647981_1 xdut.xpad15.gnesd xdut.resb_p c=3.66356e-14
c647959_7 xdut.xpad15.oeb xdut.xpad15.oebb c=1.76643e-15
c647956_4 xdut.xpad15.xggn.o1 xdut.xpad15.i2b c=1.04478e-15
c647950_10 xdut.xpad14.xggp.o1 xdut.xpad14.i1b c=1.04724e-15
c647949_16 xdut.xpad14.ib xdut.xpad14.ibb c=1.56795e-15
c647949_7 xdut.xpad14.ib xdut.xpad14.oebb c=1.02601e-15
c647942_1 xdut.xpad14.cb xdut.xpad14.aoutbb c=1.15359e-15
c647940_3 xdut.xpad14.pdb xdut.dab_pd c=1.02311e-15
c647936_7 xdut.xpad14.pub xdut.xpad14.pubb c=1.01336e-15
c647932_1 xdut.xpad14.gpesd xdut.dab_p c=1.2854e-14
c647931_1 xdut.xpad14.gnesd xdut.dab_p c=3.66357e-14
c647909_8 xdut.xpad14.oeb xdut.xpad14.oebb c=1.76658e-15
c647906_4 xdut.xpad14.xggn.o1 xdut.xpad14.i2b c=1.04479e-15
c647900_10 xdut.xpad13.xggp.o1 xdut.xpad13.i1b c=1.04724e-15
c647899_16 xdut.xpad13.ib xdut.xpad13.ibb c=1.56795e-15
c647899_7 xdut.xpad13.ib xdut.xpad13.oebb c=1.02598e-15
c647892_1 xdut.xpad13.cb xdut.xpad13.aoutbb c=1.15359e-15
c647890_3 xdut.xpad13.pdb xdut.intb_pd c=1.02313e-15
c647886_7 xdut.xpad13.pub xdut.xpad13.pubb c=1.01336e-15
c647882_1 xdut.xpad13.gpesd xdut.intb_p c=1.28537e-14
c647881_1 xdut.xpad13.gnesd xdut.intb_p c=3.66357e-14
c647859_8 xdut.xpad13.oeb xdut.xpad13.oebb c=1.76684e-15
c647856_4 xdut.xpad13.xggn.o1 xdut.xpad13.i2b c=1.04479e-15
cg453_2 xdut.intb_o 0 c=2.23462e-15
c453_1 xdut.intb_o xdut.intb_p c=1.40202e-15
cg452_2 xdut.intb_oe 0 c=2.89303e-15
c452_1 xdut.intb_oe xdut.intb_p c=1.22579e-15
cg451_2 xdut.intb_pu 0 c=2.43638e-15
c451_1 xdut.intb_pu xdut.intb_p c=1.41186e-15
cg450_2 xdut.intb_pd 0 c=2.84569e-15
c450_1 xdut.intb_pd xdut.intb_p c=1.40161e-15
cg449_3 xdut.intb_ie 0 c=2.75757e-15
c449_1 xdut.intb_ie xdut.intb_p c=1.41242e-15
cg448_2 xdut.intb_i 0 c=2.47865e-15
c448_1 xdut.intb_i xdut.intb_p c=1.43105e-15
cg446_3 xdut.dab_i 0 c=2.94825e-15
c446_1 xdut.dab_i xdut.dab_p c=1.2265e-15
cg445_2 xdut.dab_oe 0 c=2.79652e-15
c445_1 xdut.dab_oe xdut.dab_p c=1.23017e-15
cg444_2 xdut.dab_pd 0 c=3.02143e-15
c444_1 xdut.dab_pd xdut.dab_p c=1.20187e-15
cg443_2 xdut.dab_ie 0 c=2.90928e-15
c443_1 xdut.dab_ie xdut.dab_p c=1.20575e-15
cg442_2 xdut.dab_o 0 c=2.69408e-15
c442_1 xdut.dab_o xdut.dab_p c=1.23337e-15
cg441_2 xdut.dab_pu 0 c=2.85548e-15
c441_1 xdut.dab_pu xdut.dab_p c=1.1992e-15
cg440_3 xdut.resb_i 0 c=2.69222e-15
c440_1 xdut.resb_i xdut.resb_p c=1.20178e-15
cg438_2 xdut.net3137 0 c=5.76633e-15
c438_1 xdut.net3137 xdut.resb_p c=3.79678e-15
c190_4 xdut.xpad13.net424 xdut.net3138 c=2.09211e-15
c189_1 xdut.xpad14.net424 xdut.net2136 c=2.10975e-15
c186_1 xdut.xpad15.net424 xdut.net2139 c=2.09478e-15
c153_6 xdut.xpad13.aoutb xdut.net3138 c=1.35152e-15
c153_4 xdut.xpad13.aoutb xdut.xpad13.ie_ls c=1.79729e-15
c153_1 xdut.xpad13.aoutb xdut.xpad13.aoutbb c=1.26856e-15
c152_9 xdut.net3138 xdut.xpad13.pd_ls c=1.61031e-15
c151_5 xdut.xpad13.gnstrong xdut.xpad13.gnweak c=1.60322e-15
c151_3 xdut.xpad13.gnstrong xdut.xpad13.ds_ls c=1.44797e-15
c151_1 xdut.xpad13.gnstrong xdut.intb_p c=6.11877e-15
c150_6 xdut.xpad13.gpstrong xdut.xpad13.gpweak c=2.7983e-15
c150_2 xdut.xpad13.gpstrong xdut.xpad13.dsb_ls c=1.14377e-15
c150_1 xdut.xpad13.gpstrong xdut.intb_p c=1.9808e-14
c149_5 xdut.xpad13.gpweak xdut.xpad13.gnweak c=7.47383e-15
c149_4 xdut.xpad13.gpweak xdut.xpad13.gp c=1.50015e-15
c149_1 xdut.xpad13.gpweak xdut.intb_p c=7.44791e-15
c147_4 xdut.xpad13.gn xdut.xpad13.gnweak c=1.46058e-15
c146_7 xdut.xpad13.xlsgn.o1b xdut.xpad13.xlsgn.o1 c=1.44912e-15
c144_1 xdut.xpad13.gnweak xdut.intb_p c=2.3514e-15
c143_5 xdut.xpad13.gp xdut.xpad13.xlsgp.o1b c=1.50251e-15
c141_5 xdut.xpad13.xlsgp.o1b xdut.xpad13.xlsgp.o1 c=1.44585e-15
c137_1 xdut.xpad13.xlsds.o1b xdut.xpad13.xlsds.o1 c=1.51279e-15
c135_3 xdut.xpad13.xlsie.o1 xdut.xpad13.xlsie.o1b c=1.47491e-15
c132_1 xdut.xpad13.ie_ls xdut.xpad13.aoutbb c=2.06082e-15
c127_4 xdut.xpad13.xlspu.o1b xdut.xpad13.xlspu.o1 c=1.45521e-15
c125_3 xdut.xpad13.xlspd.o1b xdut.xpad13.xlspd.o1 c=1.45396e-15
c121_8 xdut.xpad14.gnstrong xdut.xpad14.gnweak c=1.603e-15
c121_3 xdut.xpad14.gnstrong xdut.xpad14.ds_ls c=1.44817e-15
c121_1 xdut.xpad14.gnstrong xdut.dab_p c=6.11877e-15
c120_9 xdut.xpad14.gnweak xdut.xpad14.gpweak c=7.47379e-15
c120_7 xdut.xpad14.gnweak xdut.xpad14.gn c=1.46058e-15
c120_1 xdut.xpad14.gnweak xdut.dab_p c=2.35206e-15
c119_5 xdut.xpad14.gpstrong xdut.xpad14.gpweak c=2.79158e-15
c119_2 xdut.xpad14.gpstrong xdut.xpad14.dsb_ls c=1.14377e-15
c119_1 xdut.xpad14.gpstrong xdut.dab_p c=1.98078e-14
c118_5 xdut.xpad14.gpweak xdut.xpad14.gp c=1.5003e-15
c118_1 xdut.xpad14.gpweak xdut.dab_p c=7.4479e-15
c115_6 xdut.xpad14.xlsgn.o1b xdut.xpad14.xlsgn.o1 c=1.44912e-15
c113_7 xdut.xpad14.xlsgp.o1b xdut.xpad14.xlsgp.o1 c=1.44585e-15
c113_6 xdut.xpad14.xlsgp.o1b xdut.xpad14.gp c=1.50251e-15
c107_1 xdut.xpad14.xlsds.o1b xdut.xpad14.xlsds.o1 c=1.51279e-15
c105_5 xdut.xpad14.ie_ls xdut.xpad14.aoutbb c=2.06082e-15
c105_3 xdut.xpad14.ie_ls xdut.xpad14.aoutb c=1.79729e-15
c103_5 xdut.xpad14.xlsie.o1b xdut.xpad14.xlsie.o1 c=1.47491e-15
c100_8 xdut.xpad14.xlspu.o1b xdut.xpad14.xlspu.o1 c=1.45521e-15
c98_1 xdut.xpad14.pd_ls xdut.net2136 c=1.61218e-15
c96_3 xdut.xpad14.xlspd.o1b xdut.xpad14.xlspd.o1 c=1.45396e-15
c93_3 xdut.xpad14.aoutbb xdut.xpad14.aoutb c=1.26856e-15
c91_1 xdut.xpad14.aoutb xdut.net2136 c=1.35212e-15
c88_8 xdut.xpad15.gnstrong xdut.xpad15.gnweak c=1.60297e-15
c88_3 xdut.xpad15.gnstrong xdut.xpad15.ds_ls c=1.44797e-15
c88_1 xdut.xpad15.gnstrong xdut.resb_p c=6.11877e-15
c87_9 xdut.xpad15.gnweak xdut.xpad15.gpweak c=7.47477e-15
c87_7 xdut.xpad15.gnweak xdut.xpad15.gn c=1.4613e-15
c87_1 xdut.xpad15.gnweak xdut.resb_p c=2.34855e-15
c86_5 xdut.xpad15.gpstrong xdut.xpad15.gpweak c=2.79464e-15
c86_2 xdut.xpad15.gpstrong xdut.xpad15.dsb_ls c=1.14377e-15
c86_1 xdut.xpad15.gpstrong xdut.resb_p c=1.98081e-14
c85_4 xdut.xpad15.gpweak xdut.xpad15.gp c=1.5003e-15
c85_1 xdut.xpad15.gpweak xdut.resb_p c=7.44805e-15
c82_6 xdut.xpad15.xlsgn.o1b xdut.xpad15.xlsgn.o1 c=1.44912e-15
c80_7 xdut.xpad15.xlsgp.o1b xdut.xpad15.xlsgp.o1 c=1.44585e-15
c80_6 xdut.xpad15.xlsgp.o1b xdut.xpad15.gp c=1.50251e-15
c74_1 xdut.xpad15.xlsds.o1b xdut.xpad15.xlsds.o1 c=1.51279e-15
c72_5 xdut.xpad15.ie_ls xdut.xpad15.aoutbb c=2.06049e-15
c72_3 xdut.xpad15.ie_ls xdut.xpad15.aoutb c=1.79884e-15
c70_5 xdut.xpad15.xlsie.o1b xdut.xpad15.xlsie.o1 c=1.47491e-15
c67_8 xdut.xpad15.xlspu.o1b xdut.xpad15.xlspu.o1 c=1.45521e-15
c65_1 xdut.xpad15.pd_ls xdut.net2139 c=1.61031e-15
c63_3 xdut.xpad15.xlspd.o1b xdut.xpad15.xlspd.o1 c=1.45396e-15
c60_3 xdut.xpad15.aoutbb xdut.xpad15.aoutb c=1.26856e-15
c58_1 xdut.xpad15.aoutb xdut.net2139 c=1.35152e-15
cg25_1 xdut.resb_p 0 c=7.218e-14
cg19_1 xdut.intb_p 0 c=4.52591e-14
cg18_1 xdut.dab_p 0 c=7.43048e-14
cg43564_7 xdut.xana.xsup.xvccreg.xreg.net1108 0 c=8.46061e-14
c43564_5 xdut.xana.xsup.xvccreg.xreg.net1108 xdut.xana.xsup.xvccreg.xreg.gate c=5.46183e-15
c43564_1 xdut.xana.xsup.xvccreg.xreg.net1108 xdut.xana.xsup.xvccreg.xreg.vbat c=1.13014e-13
c43563_1 xdut.xana.xsup.xvccreg.xreg.net799 xdut.xana.xsup.xvccreg.xreg.vbat c=1.17159e-15
cg43562_6 xdut.xana.xsup.xvccreg.xreg.net1107 0 c=1.35975e-14
c43562_5 xdut.xana.xsup.xvccreg.xreg.net1107 xdut.xana.xsup.xvccreg.xreg.p0 c=8.31384e-15
c43562_1 xdut.xana.xsup.xvccreg.xreg.net1107 xdut.xana.xsup.xvccreg.xreg.vbat c=1.82406e-14
cg43561_16 xdut.xana.xsup.xvccreg.xreg.gate 0 c=4.24763e-13
c43561_15 xdut.xana.xsup.xvccreg.xreg.gate xdut.xana.xsup.xvccreg.xreg.net930 c=1.40423e-15
c43561_14 xdut.xana.xsup.xvccreg.xreg.gate xdut.xana.xsup.xvccreg.xreg.p0 c=1.16582e-15
c43561_10 xdut.xana.xsup.xvccreg.xreg.gate xdut.xana.xsup.xvccreg.xreg.vglim c=1.65481e-15
c43561_4 xdut.xana.xsup.xvccreg.xreg.gate xdut.xana.xsup.xvccreg.xreg.net830 c=1.34695e-14
c43561_1 xdut.xana.xsup.xvccreg.xreg.gate xdut.xana.xsup.xvccreg.xreg.vbat c=1.24523e-13
cg43553_16 xdut.xana.xsup.xvccreg.xreg.p0 0 c=2.99681e-14
c43553_15 xdut.xana.xsup.xvccreg.xreg.p0 xdut.xana.xsup.xvccreg.xreg.net878 c=4.51651e-15
c43553_11 xdut.xana.xsup.xvccreg.xreg.p0 xdut.xana.xsup.xvccreg.xreg.net770 c=3.32478e-15
c43553_9 xdut.xana.xsup.xvccreg.xreg.p0 xdut.xana.xsup.xvccreg.xreg.net1037 c=4.58526e-15
c43553_6 xdut.xana.xsup.xvccreg.xreg.p0 xdut.xana.xsup.xvccreg.xreg.n2_net c=7.59597e-15
c43553_4 xdut.xana.xsup.xvccreg.xreg.p0 xdut.xana.xsup.xvccreg.xreg.net830 c=6.94363e-15
c43553_3 xdut.xana.xsup.xvccreg.xreg.p0 xdut.xana.xsup.xvccreg.xreg.net851 c=2.17732e-14
c43553_2 xdut.xana.xsup.xvccreg.xreg.p0 xdut.xana.xsup.xvccreg.xreg.net818 c=9.43981e-15
c43553_1 xdut.xana.xsup.xvccreg.xreg.p0 xdut.xana.xsup.xvccreg.xreg.vbat c=4.44425e-14
cg43552_17 xdut.xana.xsup.xvccreg.xreg.net1078 0 c=1.59059e-14
cg43544_66 xdut.xana.xsup.xvccreg.xreg.err_amp_base 0 c=7.59753e-14
cg43543_7 xdut.xana.xsup.xvccreg.xreg.net878 0 c=1.61088e-14
c43543_2 xdut.xana.xsup.xvccreg.xreg.net878 xdut.xana.xsup.xvccreg.xreg.n1_net c=8.53994e-15
c43543_1 xdut.xana.xsup.xvccreg.xreg.net878 xdut.xana.xsup.xvccreg.xreg.net818 c=1.02898e-15
cg43542_12 xdut.xana.xsup.xvccreg.xreg.gain_i 0 c=2.06426e-14
c43542_5 xdut.xana.xsup.xvccreg.xreg.gain_i xdut.xana.xsup.xvccreg.xreg.n2_net c=1.37766e-14
cg43540_10 xdut.xana.xsup.xvccreg.xreg.startup_int 0 c=1.26682e-14
cg43539_4 xdut.xana.xsup.xvccreg.xreg.vglim 0 c=1.38436e-15
c43539_1 xdut.xana.xsup.xvccreg.xreg.vglim xdut.xana.xsup.xvccreg.xreg.net818 c=2.53624e-15
cg43538_4 xdut.xana.xsup.xvccreg.xreg.net770 0 c=9.70269e-15
c43538_2 xdut.xana.xsup.xvccreg.xreg.net770 xdut.xana.xsup.xvccreg.xreg.net818 c=1.94016e-15
c43538_1 xdut.xana.xsup.xvccreg.xreg.net770 xdut.xana.xsup.xvccreg.xreg.vbat c=9.11542e-15
cg43534_3 xdut.xana.xsup.xvccreg.xreg.n0 0 c=3.03919e-15
c43534_2 xdut.xana.xsup.xvccreg.xreg.n0 xdut.xana.xsup.xvccreg.xreg.n2_net c=3.6931e-15
c43534_1 xdut.xana.xsup.xvccreg.xreg.n0 xdut.xana.xsup.xvccreg.xreg.n1_net c=5.62499e-15
cg43533_2 xdut.xana.xsup.xvccreg.xreg.net1037 0 c=1.04352e-14
c43533_1 xdut.xana.xsup.xvccreg.xreg.net1037 xdut.xana.xsup.xvccreg.xreg.vbat c=2.34127e-14
c43532_5 xdut.xana.xsup.xvccreg.rdiv<9> xdut.xana.xsup.xvccreg.rdiv<90> c=1.02502e-15
c43532_4 xdut.xana.xsup.xvccreg.rdiv<9> xdut.xana.xsup.xvccreg.rdiv<8> c=1.17002e-15
c43530_4 xdut.xana.xsup.xvccreg.rdiv<98> xdut.xana.xsup.xvccreg.rdiv<97> c=1.16997e-15
c43530_1 xdut.xana.xsup.xvccreg.rdiv<98> xdut.xana.xsup.xvccreg.rdiv<1> c=1.02502e-15
c43529_3 xdut.xana.xsup.xvccreg.rdiv<97> xdut.xana.xsup.xvccreg.rdiv<2> c=1.02502e-15
c43528_6 xdut.xana.xsup.xvccreg.rdiv<96> xdut.xana.xsup.xvccreg.rdiv<95> c=1.16997e-15
c43528_3 xdut.xana.xsup.xvccreg.rdiv<96> xdut.xana.xsup.xvccreg.rdiv<3> c=1.02502e-15
c43527_3 xdut.xana.xsup.xvccreg.rdiv<95> xdut.xana.xsup.xvccreg.rdiv<4> c=1.02502e-15
c43526_5 xdut.xana.xsup.xvccreg.rdiv<94> xdut.xana.xsup.xvccreg.rdiv<93> c=1.16988e-15
c43526_2 xdut.xana.xsup.xvccreg.rdiv<94> xdut.xana.xsup.xvccreg.rdiv<5> c=1.02505e-15
c43525_3 xdut.xana.xsup.xvccreg.rdiv<93> xdut.xana.xsup.xvccreg.rdiv<6> c=1.02502e-15
c43524_5 xdut.xana.xsup.xvccreg.rdiv<92> xdut.xana.xsup.xvccreg.rdiv<91> c=1.16997e-15
c43524_3 xdut.xana.xsup.xvccreg.rdiv<92> xdut.xana.xsup.xvccreg.rdiv<7> c=1.02502e-15
c43523_5 xdut.xana.xsup.xvccreg.rdiv<91> xdut.xana.xsup.xvccreg.rdiv<8> c=1.02502e-15
c43522_3 xdut.xana.xsup.xvccreg.rdiv<90> xdut.xana.xsup.xvccreg.rdiv<89> c=1.16997e-15
c43520_2 xdut.xana.xsup.xvccreg.rdiv<89> xdut.xana.xsup.xvccreg.rdiv<10> c=1.02502e-15
c43519_5 xdut.xana.xsup.xvccreg.rdiv<88> xdut.xana.xsup.xvccreg.rdiv<87> c=1.16997e-15
c43519_2 xdut.xana.xsup.xvccreg.rdiv<88> xdut.xana.xsup.xvccreg.rdiv<11> c=1.02502e-15
c43518_3 xdut.xana.xsup.xvccreg.rdiv<87> xdut.xana.xsup.xvccreg.rdiv<12> c=1.02502e-15
c43517_5 xdut.xana.xsup.xvccreg.rdiv<86> xdut.xana.xsup.xvccreg.rdiv<85> c=1.16988e-15
c43517_2 xdut.xana.xsup.xvccreg.rdiv<86> xdut.xana.xsup.xvccreg.rdiv<13> c=1.02505e-15
c43516_3 xdut.xana.xsup.xvccreg.rdiv<85> xdut.xana.xsup.xvccreg.rdiv<14> c=1.02502e-15
c43515_5 xdut.xana.xsup.xvccreg.rdiv<84> xdut.xana.xsup.xvccreg.rdiv<83> c=1.16997e-15
c43515_2 xdut.xana.xsup.xvccreg.rdiv<84> xdut.xana.xsup.xvccreg.rdiv<15> c=1.02502e-15
c43514_3 xdut.xana.xsup.xvccreg.rdiv<83> xdut.xana.xsup.xvccreg.rdiv<16> c=1.02502e-15
c43513_5 xdut.xana.xsup.xvccreg.rdiv<82> xdut.xana.xsup.xvccreg.rdiv<81> c=1.16997e-15
c43513_2 xdut.xana.xsup.xvccreg.rdiv<82> xdut.xana.xsup.xvccreg.rdiv<17> c=1.02502e-15
c43512_3 xdut.xana.xsup.xvccreg.rdiv<81> xdut.xana.xsup.xvccreg.rdiv<18> c=1.02502e-15
c43511_5 xdut.xana.xsup.xvccreg.rdiv<80> xdut.xana.xsup.xvccreg.rdiv<79> c=1.16997e-15
c43511_2 xdut.xana.xsup.xvccreg.rdiv<80> xdut.xana.xsup.xvccreg.rdiv<19> c=1.02502e-15
c43510_2 xdut.xana.xsup.xvccreg.rdiv<7> xdut.xana.xsup.xvccreg.rdiv<6> c=1.17002e-15
c43509_3 xdut.xana.xsup.xvccreg.rdiv<79> xdut.xana.xsup.xvccreg.rdiv<20> c=1.02502e-15
c43508_5 xdut.xana.xsup.xvccreg.rdiv<78> xdut.xana.xsup.xvccreg.rdiv<77> c=1.16988e-15
c43508_2 xdut.xana.xsup.xvccreg.rdiv<78> xdut.xana.xsup.xvccreg.rdiv<21> c=1.02505e-15
c43507_3 xdut.xana.xsup.xvccreg.rdiv<77> xdut.xana.xsup.xvccreg.rdiv<22> c=1.02502e-15
c43506_5 xdut.xana.xsup.xvccreg.rdiv<76> xdut.xana.xsup.xvccreg.rdiv<75> c=1.16997e-15
c43506_2 xdut.xana.xsup.xvccreg.rdiv<76> xdut.xana.xsup.xvccreg.rdiv<23> c=1.02502e-15
c43505_3 xdut.xana.xsup.xvccreg.rdiv<75> xdut.xana.xsup.xvccreg.rdiv<24> c=1.02502e-15
c43504_5 xdut.xana.xsup.xvccreg.rdiv<74> xdut.xana.xsup.xvccreg.rdiv<73> c=1.16997e-15
c43504_1 xdut.xana.xsup.xvccreg.rdiv<74> xdut.xana.xsup.xvccreg.rdiv<25> c=1.02502e-15
c43503_3 xdut.xana.xsup.xvccreg.rdiv<73> xdut.xana.xsup.xvccreg.rdiv<26> c=1.02502e-15
c43502_5 xdut.xana.xsup.xvccreg.rdiv<72> xdut.xana.xsup.xvccreg.rdiv<71> c=1.16997e-15
c43502_3 xdut.xana.xsup.xvccreg.rdiv<72> xdut.xana.xsup.xvccreg.rdiv<27> c=1.02502e-15
c43501_2 xdut.xana.xsup.xvccreg.rdiv<71> xdut.xana.xsup.xvccreg.rdiv<28> c=1.02502e-15
c43500_5 xdut.xana.xsup.xvccreg.rdiv<70> xdut.xana.xsup.xvccreg.rdiv<69> c=1.16988e-15
c43500_1 xdut.xana.xsup.xvccreg.rdiv<70> xdut.xana.xsup.xvccreg.rdiv<29> c=1.02505e-15
c43498_2 xdut.xana.xsup.xvccreg.rdiv<69> xdut.xana.xsup.xvccreg.rdiv<30> c=1.02502e-15
c43497_6 xdut.xana.xsup.xvccreg.rdiv<68> xdut.xana.xsup.xvccreg.rdiv<67> c=1.16997e-15
c43497_3 xdut.xana.xsup.xvccreg.rdiv<68> xdut.xana.xsup.xvccreg.rdiv<31> c=1.02502e-15
c43496_4 xdut.xana.xsup.xvccreg.rdiv<67> xdut.xana.xsup.xvccreg.rdiv<32> c=1.02502e-15
c43495_7 xdut.xana.xsup.xvccreg.rdiv<66> xdut.xana.xsup.xvccreg.rdiv<65> c=1.16997e-15
c43495_4 xdut.xana.xsup.xvccreg.rdiv<66> xdut.xana.xsup.xvccreg.rdiv<33> c=1.02502e-15
c43494_4 xdut.xana.xsup.xvccreg.rdiv<65> xdut.xana.xsup.xvccreg.rdiv<34> c=1.02502e-15
c43493_6 xdut.xana.xsup.xvccreg.rdiv<64> xdut.xana.xsup.xvccreg.rdiv<63> c=1.16997e-15
c43493_2 xdut.xana.xsup.xvccreg.rdiv<64> xdut.xana.xsup.xvccreg.rdiv<35> c=1.02502e-15
c43492_3 xdut.xana.xsup.xvccreg.rdiv<63> xdut.xana.xsup.xvccreg.rdiv<36> c=1.02502e-15
c43491_6 xdut.xana.xsup.xvccreg.rdiv<62> xdut.xana.xsup.xvccreg.rdiv<61> c=1.16988e-15
c43491_3 xdut.xana.xsup.xvccreg.rdiv<62> xdut.xana.xsup.xvccreg.rdiv<37> c=1.02505e-15
c43490_3 xdut.xana.xsup.xvccreg.rdiv<61> xdut.xana.xsup.xvccreg.rdiv<38> c=1.02502e-15
c43489_6 xdut.xana.xsup.xvccreg.rdiv<60> xdut.xana.xsup.xvccreg.rdiv<59> c=1.16997e-15
c43489_3 xdut.xana.xsup.xvccreg.rdiv<60> xdut.xana.xsup.xvccreg.rdiv<39> c=1.02502e-15
c43488_2 xdut.xana.xsup.xvccreg.rdiv<5> xdut.xana.xsup.xvccreg.rdiv<4> c=1.17002e-15
c43487_3 xdut.xana.xsup.xvccreg.rdiv<59> xdut.xana.xsup.xvccreg.rdiv<40> c=1.02502e-15
c43486_6 xdut.xana.xsup.xvccreg.rdiv<58> xdut.xana.xsup.xvccreg.rdiv<57> c=1.16997e-15
c43486_3 xdut.xana.xsup.xvccreg.rdiv<58> xdut.xana.xsup.xvccreg.rdiv<41> c=1.02502e-15
c43485_3 xdut.xana.xsup.xvccreg.rdiv<57> xdut.xana.xsup.xvccreg.rdiv<42> c=1.02502e-15
c43484_6 xdut.xana.xsup.xvccreg.rdiv<56> xdut.xana.xsup.xvccreg.rdiv<55> c=1.16997e-15
c43484_3 xdut.xana.xsup.xvccreg.rdiv<56> xdut.xana.xsup.xvccreg.rdiv<43> c=1.02502e-15
c43483_3 xdut.xana.xsup.xvccreg.rdiv<55> xdut.xana.xsup.xvccreg.rdiv<44> c=1.02502e-15
c43482_7 xdut.xana.xsup.xvccreg.rdiv<54> xdut.xana.xsup.xvccreg.rdiv<53> c=1.16988e-15
c43482_4 xdut.xana.xsup.xvccreg.rdiv<54> xdut.xana.xsup.xvccreg.rdiv<45> c=1.02505e-15
c43481_4 xdut.xana.xsup.xvccreg.rdiv<53> xdut.xana.xsup.xvccreg.rdiv<46> c=1.02502e-15
c43480_5 xdut.xana.xsup.xvccreg.rdiv<51> xdut.xana.xsup.xvccreg.rdiv<48> c=1.02502e-15
c43480_2 xdut.xana.xsup.xvccreg.rdiv<51> xdut.xana.xsup.xvccreg.rdiv<52> c=1.16997e-15
c43479_6 xdut.xana.xsup.xvccreg.rdiv<50> xdut.xana.xsup.xvccreg.rdiv<49> c=1.17e-15
c43479_4 xdut.xana.xsup.xvccreg.rdiv<50> xdut.xana.xsup.xvrrmon.xrdiv.net132 c=1.0248e-15
c43477_3 xdut.xana.xsup.xvccreg.rdiv<49> xdut.xana.xsup.xvccreg.rdiv<48> c=1.17002e-15
c43475_3 xdut.xana.xsup.xvccreg.rdiv<47> xdut.xana.xsup.xvccreg.rdiv<46> c=1.17002e-15
c43475_2 xdut.xana.xsup.xvccreg.rdiv<47> xdut.xana.xsup.xvccreg.rdiv<52> c=1.02502e-15
c43473_2 xdut.xana.xsup.xvccreg.rdiv<45> xdut.xana.xsup.xvccreg.rdiv<44> c=1.17002e-15
c43471_2 xdut.xana.xsup.xvccreg.rdiv<43> xdut.xana.xsup.xvccreg.rdiv<42> c=1.17002e-15
c43469_2 xdut.xana.xsup.xvccreg.rdiv<41> xdut.xana.xsup.xvccreg.rdiv<40> c=1.17002e-15
c43467_2 xdut.xana.xsup.xvccreg.rdiv<3> xdut.xana.xsup.xvccreg.rdiv<2> c=1.17002e-15
c43466_2 xdut.xana.xsup.xvccreg.rdiv<39> xdut.xana.xsup.xvccreg.rdiv<38> c=1.17002e-15
c43464_2 xdut.xana.xsup.xvccreg.rdiv<37> xdut.xana.xsup.xvccreg.rdiv<36> c=1.17002e-15
c43462_4 xdut.xana.xsup.xvccreg.rdiv<34> xdut.xana.xsup.xvccreg.rdiv<35> c=1.17002e-15
c43461_2 xdut.xana.xsup.xvccreg.rdiv<33> xdut.xana.xsup.xvccreg.rdiv<32> c=1.17002e-15
c43459_2 xdut.xana.xsup.xvccreg.rdiv<31> xdut.xana.xsup.xvccreg.rdiv<30> c=1.17002e-15
c43456_2 xdut.xana.xsup.xvccreg.rdiv<27> xdut.xana.xsup.xvccreg.rdiv<26> c=1.17002e-15
c43454_1 xdut.xana.xsup.xvccreg.rdiv<24> xdut.xana.xsup.xvccreg.rdiv<25> c=1.17002e-15
c43453_2 xdut.xana.xsup.xvccreg.rdiv<23> xdut.xana.xsup.xvccreg.rdiv<22> c=1.17002e-15
c43451_2 xdut.xana.xsup.xvccreg.rdiv<21> xdut.xana.xsup.xvccreg.rdiv<20> c=1.17002e-15
c43448_2 xdut.xana.xsup.xvccreg.rdiv<19> xdut.xana.xsup.xvccreg.rdiv<18> c=1.17002e-15
c43446_2 xdut.xana.xsup.xvccreg.rdiv<17> xdut.xana.xsup.xvccreg.rdiv<16> c=1.17002e-15
c43444_2 xdut.xana.xsup.xvccreg.rdiv<15> xdut.xana.xsup.xvccreg.rdiv<14> c=1.17002e-15
c43442_2 xdut.xana.xsup.xvccreg.rdiv<13> xdut.xana.xsup.xvccreg.rdiv<12> c=1.17002e-15
c43440_2 xdut.xana.xsup.xvccreg.rdiv<11> xdut.xana.xsup.xvccreg.rdiv<10> c=1.17002e-15
cg43436_2 xdut.xana.xsup.xvrrmon.xrdiv.net132 0 c=1.21785e-15
cg43429_20 xdut.xana.xsup.vcc_uv_5v 0 c=1.4745e-15
c43429_14 xdut.xana.xsup.vcc_uv_5v xdut.xana.xsup.xvccreg.xcomp.net60 c=1.42702e-15
c43429_11 xdut.xana.xsup.vcc_uv_5v xdut.xana.xsup.xvccreg.xcomp.nn6 c=1.20119e-15
c43422_13 xdut.xana.xsup.xvccreg.divh xdut.xana.xsup.xvccreg.divl c=2.85342e-15
c43421_4 xdut.xana.xsup.xvccreg.xcomp.inp xdut.xana.xsup.xvccreg.xcomp.nn1 c=1.15751e-15
c43421_3 xdut.xana.xsup.xvccreg.xcomp.inp xdut.xana.xsup.xvccreg.xcomp.nn2 c=3.32989e-15
c43421_1 xdut.xana.xsup.xvccreg.xcomp.inp xdut.xana.xsup.xvccreg.vbg_int c=2.22611e-15
c43419_8 xdut.xana.xsup.xvccreg.xcomp.enb xdut.xana.xsup.xvccreg.xcomp.nn4 c=3.3314e-15
cg43418_7 xdut.xana.xsup.xvccreg.xcomp.net60 0 c=1.77665e-15
c43418_4 xdut.xana.xsup.xvccreg.xcomp.net60 xdut.xana.xsup.xvccreg.xcomp.nn6 c=1.85875e-15
cg43417_13 xdut.xana.xsup.xvccreg.net68 0 c=3.7711e-15
cg43416_6 xdut.xana.xsup.xvccreg.net64 0 c=1.34033e-15
cg43415_9 xdut.xana.xsup.xvccreg.xcomp.nn4 0 c=1.37317e-15
c43415_8 xdut.xana.xsup.xvccreg.xcomp.nn4 xdut.xana.xsup.xvccreg.xcomp.nn6 c=2.73003e-15
cg43414_8 xdut.xana.xsup.xvccreg.xcomp.nn6 0 c=1.43996e-15
c43414_6 xdut.xana.xsup.xvccreg.xcomp.nn6 xdut.xana.xsup.xvccreg.xcomp.nnvc c=1.64286e-15
cg43412_12 xdut.xana.xsup.xvccreg.xcomp.nnvc 0 c=4.30164e-15
c43412_1 xdut.xana.xsup.xvccreg.xcomp.nnvc xdut.xana.xsup.xvccreg.vbg_int c=3.15347e-15
c43410_3 xdut.xana.xsup.xvccreg.xcomp.nn3 xdut.xana.xsup.xvccreg.xcomp.nn1 c=5.3867e-15
c43410_2 xdut.xana.xsup.xvccreg.xcomp.nn3 xdut.xana.xsup.xvccreg.xcomp.nn2 c=3.50354e-15
c43410_1 xdut.xana.xsup.xvccreg.xcomp.nn3 xdut.xana.xsup.xvccreg.vbg_int c=1.26811e-15
cg43409_3 xdut.xana.xsup.xvccreg.xcomp.nn1 0 c=1.22914e-15
c43409_2 xdut.xana.xsup.xvccreg.xcomp.nn1 xdut.xana.xsup.xvccreg.xcomp.nn2 c=2.47553e-15
c43409_1 xdut.xana.xsup.xvccreg.xcomp.nn1 xdut.xana.xsup.xvccreg.vbg_int c=1.6671e-15
cg43404_9 xdut.xana.xsup.xvddreg.xvddreg.nbl1 0 c=4.08399e-14
c43404_1 xdut.xana.xsup.xvddreg.xvddreg.nbl1 xdut.xana.xsup.xvccreg.xreg.vbat c=4.34599e-15
cg43403_2 xdut.xana.xsup.xvccreg.rdiv<28> 0 c=1.73322e-15
c43403_1 xdut.xana.xsup.xvccreg.rdiv<28> xdut.xana.xsup.xvccreg.rdiv<29> c=1.24401e-15
cg43402_7 xdut.xana.xsup.xvccreg.rdiv<25> 0 c=1.30635e-14
c43402_4 xdut.xana.xsup.xvccreg.rdiv<25> xdut.xana.xsup.xvccreg.xreg.net830 c=1.12272e-15
c43402_2 xdut.xana.xsup.xvccreg.rdiv<25> xdut.xana.xsup.xvccreg.xreg.net818 c=1.49014e-14
c43402_1 xdut.xana.xsup.xvccreg.rdiv<25> xdut.xana.xsup.xvccreg.xreg.vbat c=1.55073e-15
cg43401_1 xdut.xana.xsup.xvccreg.rdiv<29> 0 c=6.24337e-15
cg43397_1 xdut.xana.xsup.xvccreg.vbg_int 0 c=2.15762e-14
cg42796_2 xdut.xana.xldo.xuvcomp.nn1 0 c=1.17594e-15
c42666_2 xdut.xana.ln_ldo.n_464 xdut.xana.ln_ldo.n_463 c=4.78654e-15
c42666_1 xdut.xana.ln_ldo.n_464 xdut.xana.ln_ldo.n_462 c=4.80003e-15
c42595_2 xdut.xana.ln_ldo.n_1022 xdut.xana.ln_ldo.n_1020 c=4.52888e-15
c42594_3 xdut.xana.ln_ldo.n_1021 xdut.xana.ln_ldo.n_1020 c=4.52519e-15
c42594_2 xdut.xana.ln_ldo.n_1021 xdut.xana.ln_ldo.n_1019 c=4.52437e-15
c42591_2 xdut.xana.ln_ldo.n_1019 xdut.xana.ln_ldo.n_1018 c=4.52865e-15
c42590_1 xdut.xana.ln_ldo.n_1018 xdut.xana.ln_ldo.n_1016 c=4.52835e-15
c42589_2 xdut.xana.ln_ldo.n_1017 xdut.xana.ln_ldo.n_1016 c=4.52418e-15
cg20246_10 xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.nd4 0 c=1.95861e-15
cg20234_14 xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.idac2atb_5v_b 0 c=1.12461e-14
cg20227_5 xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.nd1 0 c=1.13046e-15
cg20119_6 xdut.xana.xdsi_ch1<0>.xrx.xiq_cmp.net462 0 c=1.16426e-15
c19996_2 xdut.xana.xdsi_ch1<0>.xrx.xflt3.inp_1 xdut.xana.xdsi_ch1<0>.xrx.net899 c=2.59066e-15
c19805_1 xdut.xana.xdsi_ch1<0>.xrx.xls9<2>.ls_a xdut.net292 c=1.6294e-15
c19804_6 xdut.xana.xdsi_ch1<0>.xrx.inp_iqcmp xdut.xana.xdsi_ch1<0>.xrx.net899 c=1.23156e-15
c19804_5 xdut.xana.xdsi_ch1<0>.xrx.inp_iqcmp xdut.xana.xdsi_ch1<0>.xrx.inn_iqcmp c=3.53716e-14
c19803_1 xdut.xana.xdsi_ch1<0>.xrx.net899 xdut.xana.xdsi_ch1<0>.xrx.inn_iqcmp c=2.30045e-15
cg19780_5 xdut.xana.xdsi_ch1<0>.xrx.inn_iqcmp 0 c=1.04597e-15
cg226_1 xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xidac.isum 0 c=3.07339e-15
cg221_5 xdut.xana.xsup.xvccreg.xreg.n2_net 0 c=1.02848e-14
c221_4 xdut.xana.xsup.xvccreg.xreg.n2_net xdut.xana.xsup.xvccreg.xreg.n1_net c=7.58155e-15
cg220_4 xdut.xana.xsup.xvccreg.xreg.n1_net 0 c=8.11754e-15
cg219_3 xdut.xana.xsup.xvccreg.xreg.net830 0 c=1.49041e-14
cg218_3 xdut.xana.xsup.xvccreg.xreg.net851 0 c=1.09495e-14
c218_1 xdut.xana.xsup.xvccreg.xreg.net851 xdut.xana.xsup.xvccreg.xreg.vbat c=1.49762e-15
cg217_2 xdut.xana.xsup.xvccreg.xreg.net818 0 c=9.74303e-15
c217_1 xdut.xana.xsup.xvccreg.xreg.net818 xdut.xana.xsup.xvccreg.xreg.vbat c=1.21731e-15
cg216_1 xdut.xana.xsup.xvccreg.xreg.vbat 0 c=4.49439e-13
c648404_10 xdut.xpad24.xggp.o1 xdut.xpad24.i1b c=1.0459e-15
c648403_17 xdut.xpad24.ib xdut.xpad24.ibb c=1.56704e-15
c648403_7 xdut.xpad24.ib xdut.xpad24.oebb c=1.02275e-15
c648396_2 xdut.xpad24.cb xdut.xpad24.aoutbb c=1.15353e-15
c648394_3 xdut.xpad24.pdb xdut.csb_pd c=1.03124e-15
c648390_7 xdut.xpad24.pub xdut.xpad24.pubb c=1.01215e-15
c648386_1 xdut.xpad24.gpesd xdut.csb_p c=1.28551e-14
c648385_1 xdut.xpad24.gnesd xdut.csb_p c=3.66384e-14
c648363_8 xdut.xpad24.oeb xdut.xpad24.oebb c=1.77425e-15
c648360_4 xdut.xpad24.xggn.o1 xdut.xpad24.i2b c=1.04711e-15
c648354_10 xdut.xpad23.xggp.o1 xdut.xpad23.i1b c=1.0459e-15
c648353_17 xdut.xpad23.ib xdut.xpad23.ibb c=1.56704e-15
c648353_7 xdut.xpad23.ib xdut.xpad23.oebb c=1.02275e-15
c648346_3 xdut.xpad23.cb xdut.xpad23.aoutbb c=1.15353e-15
c648344_2 xdut.xpad23.pdb xdut.sck_pd c=1.03123e-15
c648340_7 xdut.xpad23.pub xdut.xpad23.pubb c=1.01215e-15
c648336_1 xdut.xpad23.gpesd xdut.sck_p c=1.28551e-14
c648335_1 xdut.xpad23.gnesd xdut.sck_p c=3.66384e-14
c648313_8 xdut.xpad23.oeb xdut.xpad23.oebb c=1.77425e-15
c648310_4 xdut.xpad23.xggn.o1 xdut.xpad23.i2b c=1.04711e-15
c648304_10 xdut.xpad22.xggp.o1 xdut.xpad22.i1b c=1.0459e-15
c648303_17 xdut.xpad22.ib xdut.xpad22.ibb c=1.56704e-15
c648303_7 xdut.xpad22.ib xdut.xpad22.oebb c=1.02275e-15
c648296_3 xdut.xpad22.cb xdut.xpad22.aoutbb c=1.15353e-15
c648294_2 xdut.xpad22.pdb xdut.sdi_pd c=1.03124e-15
c648290_7 xdut.xpad22.pub xdut.xpad22.pubb c=1.01215e-15
c648286_1 xdut.xpad22.gpesd xdut.mosi_p c=1.28552e-14
c648285_1 xdut.xpad22.gnesd xdut.mosi_p c=3.66384e-14
c648263_8 xdut.xpad22.oeb xdut.xpad22.oebb c=1.77425e-15
c648260_4 xdut.xpad22.xggn.o1 xdut.xpad22.i2b c=1.04711e-15
c554_16 xdut.xpad22.aoutbb xdut.xpad22.aoutb c=1.26454e-15
c554_6 xdut.xpad22.aoutbb xdut.xpad22.ie_ls c=2.0607e-15
c552_7 xdut.xpad22.aoutb xdut.net2131 c=1.35154e-15
c552_3 xdut.xpad22.aoutb xdut.xpad22.ie_ls c=1.79857e-15
c551_7 xdut.net2131 xdut.xpad22.pd_ls c=1.61023e-15
c551_4 xdut.net2131 xdut.xpad22.net424 c=2.1065e-15
c548_6 xdut.xpad22.xlspu.o1b xdut.xpad22.xlspu.o1 c=1.45181e-15
c545_6 xdut.xpad22.xlspd.o1b xdut.xpad22.xlspd.o1 c=1.45051e-15
c539_1 xdut.xpad22.xlsie.o1b xdut.xpad22.xlsie.o1 c=1.47131e-15
c537_6 xdut.xpad22.gp xdut.xpad22.xlsgp.o1b c=1.504e-15
c537_2 xdut.xpad22.gp xdut.xpad22.gpweak c=1.48556e-15
c536_4 xdut.xpad22.ds_ls xdut.xpad22.gnstrong c=1.43915e-15
c535_1 xdut.xpad22.dsb_ls xdut.xpad22.gpstrong c=1.13924e-15
c534_3 xdut.xpad22.xlsds.o1b xdut.xpad22.xlsds.o1 c=1.50888e-15
c531_1 xdut.xpad22.gn xdut.xpad22.gnweak c=1.44756e-15
c530_4 xdut.xpad22.xlsgn.o1b xdut.xpad22.xlsgn.o1 c=1.44568e-15
c527_1 xdut.xpad22.xlsgp.o1b xdut.xpad22.xlsgp.o1 c=1.44243e-15
c525_4 xdut.xpad22.gnstrong xdut.xpad22.gnweak c=1.59368e-15
c525_1 xdut.xpad22.gnstrong xdut.mosi_p c=6.12153e-15
c524_3 xdut.xpad22.gnweak xdut.xpad22.gpweak c=7.46873e-15
c524_1 xdut.xpad22.gnweak xdut.mosi_p c=2.35885e-15
c523_2 xdut.xpad22.gpweak xdut.xpad22.gpstrong c=2.79531e-15
c523_1 xdut.xpad22.gpweak xdut.mosi_p c=7.44607e-15
c522_1 xdut.xpad22.gpstrong xdut.mosi_p c=1.9807e-14
c517_16 xdut.xpad23.aoutbb xdut.xpad23.aoutb c=1.26454e-15
c517_6 xdut.xpad23.aoutbb xdut.xpad23.ie_ls c=2.0607e-15
c515_7 xdut.xpad23.aoutb xdut.net2132 c=1.35161e-15
c515_3 xdut.xpad23.aoutb xdut.xpad23.ie_ls c=1.79857e-15
c514_8 xdut.net2132 xdut.xpad23.pd_ls c=1.61023e-15
c514_4 xdut.net2132 xdut.xpad23.net424 c=2.09949e-15
c511_6 xdut.xpad23.xlspu.o1b xdut.xpad23.xlspu.o1 c=1.45181e-15
c507_5 xdut.xpad23.xlspd.o1b xdut.xpad23.xlspd.o1 c=1.45051e-15
c447_1 xdut.xpad23.xlsie.o1b xdut.xpad23.xlsie.o1 c=1.47131e-15
c431_6 xdut.xpad23.gp xdut.xpad23.xlsgp.o1b c=1.504e-15
c431_2 xdut.xpad23.gp xdut.xpad23.gpweak c=1.48556e-15
c425_4 xdut.xpad23.ds_ls xdut.xpad23.gnstrong c=1.43915e-15
c424_1 xdut.xpad23.dsb_ls xdut.xpad23.gpstrong c=1.13924e-15
c423_3 xdut.xpad23.xlsds.o1b xdut.xpad23.xlsds.o1 c=1.50888e-15
c413_1 xdut.xpad23.gn xdut.xpad23.gnweak c=1.44771e-15
c410_4 xdut.xpad23.xlsgn.o1b xdut.xpad23.xlsgn.o1 c=1.44568e-15
c401_1 xdut.xpad23.xlsgp.o1b xdut.xpad23.xlsgp.o1 c=1.44243e-15
cg399_7 xdut.sdi_pu 0 c=1.95579e-15
c399_4 xdut.sdi_pu xdut.sdi_pd c=8.24688e-15
c399_1 xdut.sdi_pu xdut.mosi_p c=2.70268e-15
cg398_6 xdut.sdi_i 0 c=2.60146e-15
c398_5 xdut.sdi_i xdut.sdi_ie c=8.25378e-15
c398_3 xdut.sdi_i xdut.sdi_o c=8.27494e-15
c398_1 xdut.sdi_i xdut.mosi_p c=2.67619e-15
cg397_5 xdut.sdi_ie 0 c=2.47988e-15
c397_4 xdut.sdi_ie xdut.sdi_pd c=8.24379e-15
c397_1 xdut.sdi_ie xdut.mosi_p c=2.70901e-15
cg396_4 xdut.sdi_pd 0 c=2.26332e-15
c396_1 xdut.sdi_pd xdut.mosi_p c=2.73105e-15
cg395_3 xdut.sdi_o 0 c=2.31593e-15
c395_2 xdut.sdi_o xdut.sdi_oe c=8.32196e-15
c395_1 xdut.sdi_o xdut.mosi_p c=2.64562e-15
cg394_2 xdut.sdi_oe 0 c=2.84957e-15
c394_1 xdut.sdi_oe xdut.mosi_p c=2.85236e-15
cg393_13 xdut.sck_pu 0 c=4.27214e-15
c393_12 xdut.sck_pu xdut.sck_pd c=1.48038e-14
c393_1 xdut.sck_pu xdut.sck_p c=2.85229e-15
cg392_12 xdut.sck_pd 0 c=3.82125e-15
c392_9 xdut.sck_pd xdut.sck_ie c=1.47161e-14
c392_1 xdut.sck_pd xdut.sck_p c=2.64946e-15
cg391_11 xdut.sck_o 0 c=3.60297e-15
c391_10 xdut.sck_o xdut.sck_i c=1.46942e-14
c391_8 xdut.sck_o xdut.sck_oe c=1.468e-14
c391_1 xdut.sck_o xdut.sck_p c=2.70485e-15
cg390_10 xdut.sck_i 0 c=3.80434e-15
c390_9 xdut.sck_i xdut.sck_ie c=1.47156e-14
c390_1 xdut.sck_i xdut.sck_p c=2.68402e-15
cg389_9 xdut.sck_ie 0 c=3.98133e-15
c389_1 xdut.sck_ie xdut.sck_p c=2.66528e-15
cg388_8 xdut.sck_oe 0 c=3.49151e-15
c388_7 xdut.sck_oe xdut.csb_pu c=1.45993e-14
c388_1 xdut.sck_oe xdut.sck_p c=2.70346e-15
cg387_8 xdut.csb_pu 0 c=1.37245e-14
c387_7 xdut.csb_pu xdut.csb_pd c=3.11558e-14
c387_6 xdut.csb_pu xdut.csb_ie c=1.75115e-15
c387_2 xdut.csb_pu xdut.csb_p c=4.16013e-15
c387_1 xdut.csb_pu xdut.sck_p c=2.81303e-15
cg386_7 xdut.csb_pd 0 c=9.12661e-15
c386_6 xdut.csb_pd xdut.csb_ie c=3.06763e-14
c386_5 xdut.csb_pd xdut.csb_i c=1.76942e-15
c386_2 xdut.csb_pd xdut.csb_p c=2.71491e-15
c386_1 xdut.csb_pd xdut.sck_p c=2.6392e-15
cg385_6 xdut.csb_ie 0 c=9.1626e-15
c385_5 xdut.csb_ie xdut.csb_i c=3.0678e-14
c385_3 xdut.csb_ie xdut.csb_o c=1.75673e-15
c385_2 xdut.csb_ie xdut.csb_p c=2.70213e-15
c385_1 xdut.csb_ie xdut.sck_p c=2.63631e-15
cg384_5 xdut.csb_i 0 c=8.96834e-15
c384_4 xdut.csb_i xdut.csb_oe c=1.744e-15
c384_3 xdut.csb_i xdut.csb_o c=3.06548e-14
c384_2 xdut.csb_i xdut.csb_p c=2.72917e-15
c384_1 xdut.csb_i xdut.sck_p c=2.65423e-15
cg383_4 xdut.csb_oe 0 c=1.81146e-14
c383_3 xdut.csb_oe xdut.csb_o c=3.1492e-14
c383_2 xdut.csb_oe xdut.csb_p c=4.11693e-15
c383_1 xdut.csb_oe xdut.sck_p c=4.40122e-15
cg382_3 xdut.csb_o 0 c=9.00043e-15
c382_2 xdut.csb_o xdut.csb_p c=2.69261e-15
c382_1 xdut.csb_o xdut.sck_p c=2.63101e-15
c381_4 xdut.xpad23.gnstrong xdut.xpad23.gnweak c=1.59368e-15
c381_1 xdut.xpad23.gnstrong xdut.sck_p c=6.12153e-15
c380_3 xdut.xpad23.gnweak xdut.xpad23.gpweak c=7.46829e-15
c380_1 xdut.xpad23.gnweak xdut.sck_p c=2.35885e-15
c358_2 xdut.xpad23.gpweak xdut.xpad23.gpstrong c=2.79531e-15
c358_1 xdut.xpad23.gpweak xdut.sck_p c=7.44607e-15
c357_1 xdut.xpad23.gpstrong xdut.sck_p c=1.98068e-14
c348_15 xdut.xpad24.aoutbb xdut.xpad24.aoutb c=1.26454e-15
c348_6 xdut.xpad24.aoutbb xdut.xpad24.ie_ls c=2.0607e-15
c336_7 xdut.xpad24.aoutb xdut.net3230 c=1.35154e-15
c336_3 xdut.xpad24.aoutb xdut.xpad24.ie_ls c=1.79857e-15
c334_8 xdut.net3230 xdut.xpad24.pd_ls c=1.61023e-15
c334_2 xdut.net3230 xdut.xpad24.net424 c=2.10024e-15
c331_6 xdut.xpad24.xlspu.o1b xdut.xpad24.xlspu.o1 c=1.45181e-15
c316_5 xdut.xpad24.xlspd.o1b xdut.xpad24.xlspd.o1 c=1.45051e-15
c265_1 xdut.xpad24.xlsie.o1b xdut.xpad24.xlsie.o1 c=1.47131e-15
c263_10 xdut.xpad24.gp xdut.xpad24.xlsgp.o1b c=1.504e-15
c263_1 xdut.xpad24.gp xdut.xpad24.gpweak c=1.48556e-15
c261_4 xdut.xpad24.ds_ls xdut.xpad24.gnstrong c=1.43936e-15
c259_2 xdut.xpad24.dsb_ls xdut.xpad24.gpstrong c=1.13926e-15
c258_3 xdut.xpad24.xlsds.o1b xdut.xpad24.xlsds.o1 c=1.50888e-15
c256_3 xdut.xpad24.xlsgp.o1b xdut.xpad24.xlsgp.o1 c=1.44243e-15
c253_1 xdut.xpad24.gn xdut.xpad24.gnweak c=1.44771e-15
c252_2 xdut.xpad24.xlsgn.o1b xdut.xpad24.xlsgn.o1 c=1.44568e-15
c250_4 xdut.xpad24.gnstrong xdut.xpad24.gnweak c=1.59611e-15
c250_1 xdut.xpad24.gnstrong xdut.csb_p c=6.12153e-15
c249_2 xdut.xpad24.gnweak xdut.xpad24.gpweak c=7.46785e-15
c249_1 xdut.xpad24.gnweak xdut.csb_p c=2.35885e-15
c248_2 xdut.xpad24.gpstrong xdut.xpad24.gpweak c=2.79736e-15
c248_1 xdut.xpad24.gpstrong xdut.csb_p c=1.9807e-14
c247_1 xdut.xpad24.gpweak xdut.csb_p c=7.44594e-15
cg15_1 xdut.csb_p 0 c=5.3713e-14
cg13_1 xdut.mosi_p 0 c=3.41991e-14
cg12_1 xdut.sck_p 0 c=3.33055e-14
c648202_10 xdut.xpad2.xggp.o1 xdut.xpad2.i1b c=1.04419e-15
c648201_15 xdut.xpad2.ib xdut.xpad2.ibb c=1.56725e-15
c648201_6 xdut.xpad2.ib xdut.xpad2.oebb c=1.02614e-15
c648194_2 xdut.xpad2.cb xdut.xpad2.aoutbb c=1.15406e-15
c648192_2 xdut.xpad2.pdb xdut.net3135 c=1.02585e-15
c648188_6 xdut.xpad2.pub xdut.xpad2.pubb c=1.01273e-15
c648184_1 xdut.xpad2.gpesd xdut.tmode_p c=1.28574e-14
c648183_1 xdut.xpad2.gnesd xdut.tmode_p c=3.6646e-14
c648161_7 xdut.xpad2.oeb xdut.xpad2.oebb c=1.76264e-15
c648158_4 xdut.xpad2.xggn.o1 xdut.xpad2.i2b c=1.04827e-15
c647851_10 xdut.xpad1.xggp.o1 xdut.xpad1.i1b c=1.04419e-15
c647850_15 xdut.xpad1.ib xdut.xpad1.ibb c=1.56809e-15
c647850_5 xdut.xpad1.ib xdut.xpad1.oebb c=1.02614e-15
c647810_6 xdut.xpad1.oeb xdut.xpad1.oebb c=1.76239e-15
c647807_3 xdut.xpad1.xggn.o1 xdut.xpad1.i2b c=1.04827e-15
c44437_4 xdut.xana.xsup.xvrrmon.rdiv<9> xdut.xana.xsup.xvrrmon.rdiv<90> c=1.07502e-15
c44437_3 xdut.xana.xsup.xvrrmon.rdiv<9> xdut.xana.xsup.xvrrmon.rdiv<8> c=1.2358e-15
c44436_1 xdut.xana.xsup.xvrrmon.rdiv<99> xdut.xana.xsup.xvrrmon.vrr_int c=1.24209e-15
c44435_6 xdut.xana.xsup.xvrrmon.rdiv<98> xdut.xana.xsup.xvrrmon.rdiv<97> c=1.23364e-15
c44435_3 xdut.xana.xsup.xvrrmon.rdiv<98> xdut.xana.xsup.xvrrmon.rdiv<1> c=1.07492e-15
c44434_2 xdut.xana.xsup.xvrrmon.rdiv<97> xdut.xana.xsup.xvrrmon.rdiv<2> c=1.0775e-15
c44433_7 xdut.xana.xsup.xvrrmon.rdiv<96> xdut.xana.xsup.xvrrmon.rdiv<95> c=1.23548e-15
c44433_4 xdut.xana.xsup.xvrrmon.rdiv<96> xdut.xana.xsup.xvrrmon.rdiv<3> c=1.07513e-15
c44432_2 xdut.xana.xsup.xvrrmon.rdiv<95> xdut.xana.xsup.xvrrmon.rdiv<4> c=1.07523e-15
c44431_7 xdut.xana.xsup.xvrrmon.rdiv<94> xdut.xana.xsup.xvrrmon.rdiv<93> c=1.23126e-15
c44431_4 xdut.xana.xsup.xvrrmon.rdiv<94> xdut.xana.xsup.xvrrmon.rdiv<5> c=1.0754e-15
c44430_2 xdut.xana.xsup.xvrrmon.rdiv<93> xdut.xana.xsup.xvrrmon.rdiv<6> c=1.06799e-15
c44429_7 xdut.xana.xsup.xvrrmon.rdiv<92> xdut.xana.xsup.xvrrmon.rdiv<91> c=1.23892e-15
c44429_5 xdut.xana.xsup.xvrrmon.rdiv<92> xdut.xana.xsup.xvrrmon.rdiv<7> c=1.07415e-15
c44428_4 xdut.xana.xsup.xvrrmon.rdiv<91> xdut.xana.xsup.xvrrmon.rdiv<8> c=1.08012e-15
c44427_5 xdut.xana.xsup.xvrrmon.rdiv<90> xdut.xana.xsup.xvrrmon.rdiv<89> c=1.23544e-15
c44425_1 xdut.xana.xsup.xvrrmon.rdiv<89> xdut.xana.xsup.xvrrmon.rdiv<10> c=1.07037e-15
c44424_7 xdut.xana.xsup.xvrrmon.rdiv<88> xdut.xana.xsup.xvrrmon.rdiv<87> c=1.23156e-15
c44424_4 xdut.xana.xsup.xvrrmon.rdiv<88> xdut.xana.xsup.xvrrmon.rdiv<11> c=1.0756e-15
c44423_2 xdut.xana.xsup.xvrrmon.rdiv<87> xdut.xana.xsup.xvrrmon.rdiv<12> c=1.0801e-15
c44422_7 xdut.xana.xsup.xvrrmon.rdiv<86> xdut.xana.xsup.xvrrmon.rdiv<85> c=1.23822e-15
c44422_4 xdut.xana.xsup.xvrrmon.rdiv<86> xdut.xana.xsup.xvrrmon.rdiv<13> c=1.07259e-15
c44421_2 xdut.xana.xsup.xvrrmon.rdiv<85> xdut.xana.xsup.xvrrmon.rdiv<14> c=1.07235e-15
c44420_7 xdut.xana.xsup.xvrrmon.rdiv<84> xdut.xana.xsup.xvrrmon.rdiv<83> c=1.22361e-15
c44420_4 xdut.xana.xsup.xvrrmon.rdiv<84> xdut.xana.xsup.xvrrmon.rdiv<15> c=1.07334e-15
c44419_2 xdut.xana.xsup.xvrrmon.rdiv<83> xdut.xana.xsup.xvrrmon.rdiv<16> c=1.07265e-15
c44418_7 xdut.xana.xsup.xvrrmon.rdiv<82> xdut.xana.xsup.xvrrmon.rdiv<81> c=1.23595e-15
c44418_4 xdut.xana.xsup.xvrrmon.rdiv<82> xdut.xana.xsup.xvrrmon.rdiv<17> c=1.07627e-15
c44417_2 xdut.xana.xsup.xvrrmon.rdiv<81> xdut.xana.xsup.xvrrmon.rdiv<18> c=1.07486e-15
c44416_6 xdut.xana.xsup.xvrrmon.rdiv<80> xdut.xana.xsup.xvrrmon.rdiv<79> c=1.23107e-15
c44416_3 xdut.xana.xsup.xvrrmon.rdiv<80> xdut.xana.xsup.xvrrmon.rdiv<19> c=1.07571e-15
c44415_1 xdut.xana.xsup.xvrrmon.rdiv<7> xdut.xana.xsup.xvrrmon.rdiv<6> c=1.23443e-15
c44414_2 xdut.xana.xsup.xvrrmon.rdiv<79> xdut.xana.xsup.xvrrmon.rdiv<20> c=1.06663e-15
c44413_6 xdut.xana.xsup.xvrrmon.rdiv<78> xdut.xana.xsup.xvrrmon.rdiv<77> c=1.24049e-15
c44413_3 xdut.xana.xsup.xvrrmon.rdiv<78> xdut.xana.xsup.xvrrmon.rdiv<21> c=1.07605e-15
c44412_3 xdut.xana.xsup.xvrrmon.rdiv<77> xdut.xana.xsup.xvrrmon.rdiv<22> c=1.07787e-15
c44411_7 xdut.xana.xsup.xvrrmon.rdiv<76> xdut.xana.xsup.xvrrmon.rdiv<75> c=1.2373e-15
c44411_4 xdut.xana.xsup.xvrrmon.rdiv<76> xdut.xana.xsup.xvrrmon.rdiv<23> c=1.07434e-15
c44410_3 xdut.xana.xsup.xvrrmon.rdiv<75> xdut.xana.xsup.xvrrmon.rdiv<24> c=1.07218e-15
c44409_7 xdut.xana.xsup.xvrrmon.rdiv<74> xdut.xana.xsup.xvrrmon.rdiv<73> c=1.2346e-15
c44409_3 xdut.xana.xsup.xvrrmon.rdiv<74> xdut.xana.xsup.xvrrmon.rdiv<25> c=1.0689e-15
c44408_3 xdut.xana.xsup.xvrrmon.rdiv<73> xdut.xana.xsup.xvrrmon.rdiv<26> c=1.07972e-15
c44407_6 xdut.xana.xsup.xvrrmon.rdiv<72> xdut.xana.xsup.xvrrmon.rdiv<71> c=1.23898e-15
c44407_4 xdut.xana.xsup.xvrrmon.rdiv<72> xdut.xana.xsup.xvrrmon.rdiv<27> c=1.07193e-15
c44406_1 xdut.xana.xsup.xvrrmon.rdiv<71> xdut.xana.xsup.xvrrmon.rdiv<28> c=1.07351e-15
c44405_7 xdut.xana.xsup.xvrrmon.rdiv<70> xdut.xana.xsup.xvrrmon.rdiv<69> c=1.22499e-15
c44405_4 xdut.xana.xsup.xvrrmon.rdiv<70> xdut.xana.xsup.xvrrmon.rdiv<29> c=1.07017e-15
c44403_2 xdut.xana.xsup.xvrrmon.rdiv<69> xdut.xana.xsup.xvrrmon.rdiv<30> c=1.07621e-15
c44402_7 xdut.xana.xsup.xvrrmon.rdiv<68> xdut.xana.xsup.xvrrmon.rdiv<67> c=1.23628e-15
c44402_4 xdut.xana.xsup.xvrrmon.rdiv<68> xdut.xana.xsup.xvrrmon.rdiv<31> c=1.07443e-15
c44401_3 xdut.xana.xsup.xvrrmon.rdiv<67> xdut.xana.xsup.xvrrmon.rdiv<32> c=1.07567e-15
c44400_7 xdut.xana.xsup.xvrrmon.rdiv<66> xdut.xana.xsup.xvrrmon.rdiv<65> c=1.22839e-15
c44400_4 xdut.xana.xsup.xvrrmon.rdiv<66> xdut.xana.xsup.xvrrmon.rdiv<33> c=1.07376e-15
c44399_3 xdut.xana.xsup.xvrrmon.rdiv<65> xdut.xana.xsup.xvrrmon.rdiv<34> c=1.07061e-15
c44398_7 xdut.xana.xsup.xvrrmon.rdiv<64> xdut.xana.xsup.xvrrmon.rdiv<63> c=1.23994e-15
c44398_2 xdut.xana.xsup.xvrrmon.rdiv<64> xdut.xana.xsup.xvrrmon.rdiv<35> c=1.07465e-15
c44397_2 xdut.xana.xsup.xvrrmon.rdiv<63> xdut.xana.xsup.xvrrmon.rdiv<36> c=1.0766e-15
c44396_7 xdut.xana.xsup.xvrrmon.rdiv<62> xdut.xana.xsup.xvrrmon.rdiv<61> c=1.23074e-15
c44396_4 xdut.xana.xsup.xvrrmon.rdiv<62> xdut.xana.xsup.xvrrmon.rdiv<37> c=1.07312e-15
c44395_3 xdut.xana.xsup.xvrrmon.rdiv<61> xdut.xana.xsup.xvrrmon.rdiv<38> c=1.06971e-15
c44394_7 xdut.xana.xsup.xvrrmon.rdiv<60> xdut.xana.xsup.xvrrmon.rdiv<59> c=1.24065e-15
c44394_4 xdut.xana.xsup.xvrrmon.rdiv<60> xdut.xana.xsup.xvrrmon.rdiv<39> c=1.07041e-15
c44393_1 xdut.xana.xsup.xvrrmon.rdiv<5> xdut.xana.xsup.xvrrmon.rdiv<4> c=1.2357e-15
c44392_3 xdut.xana.xsup.xvrrmon.rdiv<59> xdut.xana.xsup.xvrrmon.rdiv<40> c=1.07884e-15
c44391_7 xdut.xana.xsup.xvrrmon.rdiv<58> xdut.xana.xsup.xvrrmon.rdiv<57> c=1.24037e-15
c44391_4 xdut.xana.xsup.xvrrmon.rdiv<58> xdut.xana.xsup.xvrrmon.rdiv<41> c=1.07242e-15
c44390_3 xdut.xana.xsup.xvrrmon.rdiv<57> xdut.xana.xsup.xvrrmon.rdiv<42> c=1.0703e-15
c44389_7 xdut.xana.xsup.xvrrmon.rdiv<56> xdut.xana.xsup.xvrrmon.rdiv<55> c=1.23254e-15
c44389_4 xdut.xana.xsup.xvrrmon.rdiv<56> xdut.xana.xsup.xvrrmon.rdiv<43> c=1.07516e-15
c44388_3 xdut.xana.xsup.xvrrmon.rdiv<55> xdut.xana.xsup.xvrrmon.rdiv<44> c=1.07585e-15
c44387_6 xdut.xana.xsup.xvrrmon.rdiv<54> xdut.xana.xsup.xvrrmon.rdiv<53> c=1.23812e-15
c44387_3 xdut.xana.xsup.xvrrmon.rdiv<54> xdut.xana.xsup.xvrrmon.rdiv<45> c=1.07485e-15
c44386_4 xdut.xana.xsup.xvrrmon.rdiv<53> xdut.xana.xsup.xvrrmon.rdiv<46> c=1.07578e-15
c44385_5 xdut.xana.xsup.xvrrmon.rdiv<51> xdut.xana.xsup.xvrrmon.rdiv<48> c=1.07031e-15
c44385_2 xdut.xana.xsup.xvrrmon.rdiv<51> xdut.xana.xsup.xvrrmon.rdiv<52> c=1.2358e-15
c44384_5 xdut.xana.xsup.xvrrmon.rdiv<50> xdut.xana.xsup.xvrrmon.rdiv<49> c=1.23407e-15
c44382_4 xdut.xana.xsup.xvrrmon.rdiv<49> xdut.xana.xsup.xvrrmon.rdiv<48> c=1.23333e-15
c44380_3 xdut.xana.xsup.xvrrmon.rdiv<47> xdut.xana.xsup.xvrrmon.rdiv<46> c=1.23231e-15
c44380_2 xdut.xana.xsup.xvrrmon.rdiv<47> xdut.xana.xsup.xvrrmon.rdiv<52> c=1.07874e-15
c44378_2 xdut.xana.xsup.xvrrmon.rdiv<45> xdut.xana.xsup.xvrrmon.rdiv<44> c=1.24101e-15
c44376_2 xdut.xana.xsup.xvrrmon.rdiv<43> xdut.xana.xsup.xvrrmon.rdiv<42> c=1.22678e-15
c44374_2 xdut.xana.xsup.xvrrmon.rdiv<41> xdut.xana.xsup.xvrrmon.rdiv<40> c=1.24159e-15
c44372_1 xdut.xana.xsup.xvrrmon.rdiv<3> xdut.xana.xsup.xvrrmon.rdiv<2> c=1.24156e-15
c44371_2 xdut.xana.xsup.xvrrmon.rdiv<39> xdut.xana.xsup.xvrrmon.rdiv<38> c=1.23653e-15
c44369_2 xdut.xana.xsup.xvrrmon.rdiv<37> xdut.xana.xsup.xvrrmon.rdiv<36> c=1.2366e-15
c44367_2 xdut.xana.xsup.xvrrmon.rdiv<34> xdut.xana.xsup.xvrrmon.rdiv<35> c=1.23115e-15
c44366_1 xdut.xana.xsup.xvrrmon.rdiv<33> xdut.xana.xsup.xvrrmon.rdiv<32> c=1.23466e-15
c44364_1 xdut.xana.xsup.xvrrmon.rdiv<31> xdut.xana.xsup.xvrrmon.rdiv<30> c=1.239e-15
c44361_2 xdut.xana.xsup.xvrrmon.rdiv<27> xdut.xana.xsup.xvrrmon.rdiv<26> c=1.23895e-15
c44359_3 xdut.xana.xsup.xvrrmon.rdiv<24> xdut.xana.xsup.xvrrmon.rdiv<25> c=1.23344e-15
c44358_1 xdut.xana.xsup.xvrrmon.rdiv<23> xdut.xana.xsup.xvrrmon.rdiv<22> c=1.23479e-15
c44356_1 xdut.xana.xsup.xvrrmon.rdiv<21> xdut.xana.xsup.xvrrmon.rdiv<20> c=1.23216e-15
c44353_1 xdut.xana.xsup.xvrrmon.rdiv<19> xdut.xana.xsup.xvrrmon.rdiv<18> c=1.23584e-15
c44351_1 xdut.xana.xsup.xvrrmon.rdiv<17> xdut.xana.xsup.xvrrmon.rdiv<16> c=1.24016e-15
c44349_1 xdut.xana.xsup.xvrrmon.rdiv<15> xdut.xana.xsup.xvrrmon.rdiv<14> c=1.23373e-15
c44347_1 xdut.xana.xsup.xvrrmon.rdiv<13> xdut.xana.xsup.xvrrmon.rdiv<12> c=1.23829e-15
c44345_1 xdut.xana.xsup.xvrrmon.rdiv<11> xdut.xana.xsup.xvrrmon.rdiv<10> c=1.23378e-15
c44342_1 xdut.xana.xsup.xvrrmon.xrdiv.net113 xdut.xana.xsup.xvrrmon.vrr_int c=1.24608e-15
cg44341_2 xdut.xana.xsup.xvccreg.xrdiv_vdda.net132 0 c=1.59895e-15
cg44330_11 xdut.xana.xsup.xvrrmon.xcomp2.nn1 0 c=1.23993e-15
c44330_7 xdut.xana.xsup.xvrrmon.xcomp2.nn1 xdut.xana.xsup.xvrrmon.xcomp2.nn2 c=2.48405e-15
c44330_6 xdut.xana.xsup.xvrrmon.xcomp2.nn1 xdut.xana.xsup.xvrrmon.xcomp2.nn3 c=5.40581e-15
c44330_5 xdut.xana.xsup.xvrrmon.xcomp2.nn1 xdut.xana.xsup.xvrrmon.xcomp2.inp c=1.12068e-15
cg44324_10 xdut.xana.xsup.xvrrmon.xcomp1.nn1 0 c=1.17057e-15
c44324_8 xdut.xana.xsup.xvrrmon.xcomp1.nn1 xdut.xana.xsup.xvrrmon.xcomp1.nn3 c=5.42079e-15
c44324_7 xdut.xana.xsup.xvrrmon.xcomp1.nn1 xdut.xana.xsup.xvrrmon.xcomp1.inp c=1.12521e-15
c44324_4 xdut.xana.xsup.xvrrmon.xcomp1.nn1 xdut.xana.xsup.xvrrmon.xcomp1.nn2 c=2.48702e-15
c44319_1 xdut.xana.xsup.xvrrmon.rdiv<29> xdut.xana.xsup.xvrrmon.rdiv<28> c=1.2322e-15
c44316_10 xdut.xana.xsup.xvrrmon.xcomp1.nn3 xdut.xana.xsup.xvrrmon.xcomp1.inp c=1.29494e-15
c44316_6 xdut.xana.xsup.xvrrmon.xcomp1.nn3 xdut.xana.xsup.xvrrmon.xcomp1.nn2 c=3.64898e-15
c44315_6 xdut.xana.xsup.xvrrmon.xcomp1.inp xdut.xana.xsup.xvrrmon.xcomp1.nn2 c=2.7243e-15
cg44314_25 xdut.xana.xsup.xvrrmon.net52 0 c=1.20497e-14
c44314_11 xdut.xana.xsup.xvrrmon.net52 xdut.xana.xsup.xvrrmon.net54 c=2.3936e-15
c44314_4 xdut.xana.xsup.xvrrmon.net52 xdut.xana.xsup.xvrrmon.net9 c=1.11351e-14
cg44313_8 xdut.xana.xsup.xvrrmon.xcomp1.nn4 0 c=1.36402e-15
c44313_5 xdut.xana.xsup.xvrrmon.xcomp1.nn4 xdut.xana.xsup.xvrrmon.xcomp1.enb c=3.32584e-15
c44313_3 xdut.xana.xsup.xvrrmon.xcomp1.nn4 xdut.xana.xsup.xvrrmon.xcomp1.nn6 c=2.71998e-15
cg44312_14 xdut.xana.xsup.xvrrmon.xcomp1.nnvc 0 c=5.47935e-14
c44312_3 xdut.xana.xsup.xvrrmon.xcomp1.nnvc xdut.xana.xsup.xvrrmon.xcomp1.nn6 c=1.61281e-15
c44305_4 xdut.xana.xsup.xvrrmon.net4 xdut.xana.xsup.xvrrmon.xcomp1.net60 c=1.42586e-15
c44305_2 xdut.xana.xsup.xvrrmon.net4 xdut.xana.xsup.xvrrmon.vrr_ov_5v c=1.76437e-15
c44304_2 xdut.xana.xsup.xvrrmon.xcomp1.enb xdut.xana.xsup.xvrrmon.vrr_ov_5v c=1.43626e-15
c44303_10 xdut.xana.xsup.xvrrmon.xcomp2.enb xdut.xana.xsup.xvrrmon.net18 c=1.44315e-15
c44303_6 xdut.xana.xsup.xvrrmon.xcomp2.enb xdut.xana.xsup.xvrrmon.xcomp2.nn4 c=3.32589e-15
cg44302_23 xdut.xana.xsup.xvrrmon.ena 0 c=1.26466e-14
c44302_6 xdut.xana.xsup.xvrrmon.ena xdut.xana.xsup.xvrrmon.vrr_uv_5v c=2.0363e-15
cg44300_6 xdut.xana.xsup.xvrrmon.vrr_int 0 c=1.19395e-14
c44300_2 xdut.xana.xsup.xvrrmon.vrr_int xdut.xana.xsup.atst_sup_5v<4> c=2.55224e-15
c44300_1 xdut.xana.xsup.xvrrmon.vrr_int xdut.xana.xsup.xvrrmon.net42 c=2.97713e-15
cg44299_2 xdut.xana.xsup.xvrrmon.rdiv<52> 0 c=2.16367e-15
cg44298_2 xdut.xana.xsup.xvrrmon.rdiv<35> 0 c=4.83093e-15
c44288_7 xdut.xana.xsup.xvrrmon.xcomp2.nn2 xdut.xana.xsup.xvrrmon.xcomp2.nn3 c=3.64629e-15
c44288_6 xdut.xana.xsup.xvrrmon.xcomp2.nn2 xdut.xana.xsup.xvrrmon.xcomp2.inp c=2.72596e-15
cg44286_11 xdut.xana.xsup.xvrrmon.net18 0 c=1.14199e-15
c44286_4 xdut.xana.xsup.xvrrmon.net18 xdut.xana.xsup.xvrrmon.xcomp2.net60 c=1.28999e-15
c44286_3 xdut.xana.xsup.xvrrmon.net18 xdut.xana.xsup.xvrrmon.vrr_uv_5v c=1.74202e-15
c44285_8 xdut.xana.xsup.xvrrmon.xcomp2.nn3 xdut.xana.xsup.xvrrmon.xcomp2.inp c=1.28003e-15
cg44283_11 xdut.xana.xsup.xvrrmon.net54 0 c=1.19408e-14
c44283_4 xdut.xana.xsup.xvrrmon.net54 xdut.xana.xsup.xvrrmon.vrr_ov_5v c=3.58877e-15
cg44282_4 xdut.xana.xsup.xvrrmon.xcomp2.nn4 0 c=1.35541e-15
c44282_2 xdut.xana.xsup.xvrrmon.xcomp2.nn4 xdut.xana.xsup.xvrrmon.xcomp2.nn6 c=2.69973e-15
cg44281_5 xdut.xana.xsup.xvrrmon.xcomp2.nnvc 0 c=5.46132e-14
c44281_4 xdut.xana.xsup.xvrrmon.xcomp2.nnvc xdut.xana.xsup.xvrrmon.xcomp2.nn6 c=1.61597e-15
cg44280_4 xdut.xana.xsup.xvrrmon.xcomp2.nn6 0 c=1.66732e-15
c44280_3 xdut.xana.xsup.xvrrmon.xcomp2.nn6 xdut.xana.xsup.xvrrmon.xcomp2.net60 c=1.85362e-15
cg44279_3 xdut.xana.xsup.xvrrmon.xcomp2.net60 0 c=1.68614e-15
c44279_1 xdut.xana.xsup.xvrrmon.xcomp2.net60 xdut.xana.xsup.xvrrmon.vrr_uv_5v c=1.41557e-15
cg44278_3 xdut.xana.xsup.xvrrmon.xcomp1.nn6 0 c=1.57588e-15
c44278_2 xdut.xana.xsup.xvrrmon.xcomp1.nn6 xdut.xana.xsup.xvrrmon.xcomp1.net60 c=1.86631e-15
cg44277_3 xdut.xana.xsup.xvrrmon.xcomp1.net60 0 c=1.59401e-15
c44277_1 xdut.xana.xsup.xvrrmon.xcomp1.net60 xdut.xana.xsup.xvrrmon.vrr_ov_5v c=1.29074e-15
c43393_5 xdut.xana.xsup.xvbgbuf.net213 xdut.xana.xsup.xvbgbuf.vg_m5 c=2.56765e-14
c43393_4 xdut.xana.xsup.xvbgbuf.net213 xdut.xana.xsup.xvbgbuf.vgpc c=3.3471e-14
cg43392_5 xdut.xana.xsup.xvbgbuf.vg_m5 0 c=2.38214e-15
c43392_4 xdut.xana.xsup.xvbgbuf.vg_m5 xdut.xana.xsup.xvbgbuf.vgpc c=7.01881e-15
c43392_2 xdut.xana.xsup.xvbgbuf.vg_m5 xdut.xana.xsup.xvbgbuf.vgp c=2.86675e-15
c43391_3 xdut.xana.xsup.xvbgbuf.vgpc xdut.xana.xsup.xvbgbuf.net163 c=6.06772e-15
c43391_2 xdut.xana.xsup.xvbgbuf.vgpc xdut.xana.xsup.xvbgbuf.vgp c=3.36363e-15
cg43390_3 xdut.xana.xsup.xvbgbuf.net163 0 c=1.3823e-15
c43390_2 xdut.xana.xsup.xvbgbuf.net163 xdut.xana.xsup.xvbgbuf.vgp c=2.62313e-15
cg43389_3 xdut.xana.xsup.xvbgbuf.vgp 0 c=1.90254e-14
cg43386_13 xdut.xana.xsup.xref.xiconst.z 0 c=1.88803e-14
c43386_10 xdut.xana.xsup.xref.xiconst.z xdut.xana.xsup.xref.xiconst.xop.vcasn c=1.33858e-15
c43386_9 xdut.xana.xsup.xref.xiconst.z xdut.xana.xsup.xref.xiconst.xop.net40 c=1.10862e-14
c43386_8 xdut.xana.xsup.xref.xiconst.z xdut.xana.xsup.xref.xiconst.xop.vbp c=3.9324e-15
c43386_7 xdut.xana.xsup.xref.xiconst.z xdut.xana.xsup.xref.xiconst.xop.vcasp c=4.52059e-15
c43386_5 xdut.xana.xsup.xref.xiconst.z xdut.xana.xsup.xref.xiconst.xop.net43 c=9.63259e-15
c43386_4 xdut.xana.xsup.xref.xiconst.z xdut.xana.xsup.xref.xiconst.gate c=2.57937e-15
c43386_3 xdut.xana.xsup.xref.xiconst.z xdut.xana.xsup.xref.xiconst.vbuf c=1.50758e-14
c43386_2 xdut.xana.xsup.xref.xiconst.z xdut.xana.xsup.xref.vref_iconst c=1.64474e-14
cg43385_8 xdut.xana.xsup.xref.xiconst.xop.net15 0 c=2.77171e-15
cg43384_7 xdut.xana.xsup.xref.xiconst.xop.net12 0 c=2.34478e-15
cg43383_9 xdut.xana.xsup.xref.xiconst.xop.vcasn 0 c=3.75997e-15
cg43382_7 xdut.xana.xsup.xref.xiconst.xop.net40 0 c=6.80765e-15
cg43381_6 xdut.xana.xsup.xref.xiconst.xop.vbp 0 c=3.94371e-15
c43381_1 xdut.xana.xsup.xref.xiconst.xop.vbp xdut.xana.xsup.xref.iaux10u c=1.96997e-15
cg43380_7 xdut.xana.xsup.xref.xiconst.xop.vcasp 0 c=4.99602e-15
c43380_1 xdut.xana.xsup.xref.xiconst.xop.vcasp xdut.xana.xsup.xref.iaux10u c=2.38053e-15
cg43379_5 xdut.xana.xsup.xref.xiconst.xop.vbn_amp 0 c=6.87189e-15
cg43378_5 xdut.xana.xsup.xref.xiconst.xop.net43 0 c=6.6826e-15
c43378_2 xdut.xana.xsup.xref.xiconst.xop.net43 xdut.xana.xsup.xref.vref_iconst c=9.12402e-15
cg43350_17 xdut.xana.xsup.xref.xiconst.xcm2.vcasp 0 c=1.37491e-15
cg43345_10 xdut.xana.xsup.xref.xiconst.xcm2.vbn 0 c=2.12775e-15
cg43313_10 xdut.xana.xsup.xref.xiconst.xcm1.vcasp 0 c=3.42318e-15
cg43310_4 xdut.xana.xsup.xref.xiconst.xcm1.vbn 0 c=2.76661e-15
cg43307_13 xdut.xana.xsup.xref.xiconst.net234 0 c=3.86613e-15
c43307_11 xdut.xana.xsup.xref.xiconst.net234 xdut.xana.xsup.xref.xiconst.vbn c=2.63611e-15
c43307_5 xdut.xana.xsup.xref.xiconst.net234 xdut.xana.xsup.xref.xiconst.net252 c=7.14692e-15
c43307_2 xdut.xana.xsup.xref.xiconst.net234 xdut.xana.xsup.xref.xiconst.net233 c=2.01494e-15
c43307_1 xdut.xana.xsup.xref.xiconst.net234 xdut.xana.xsup.xref.xiconst.net245 c=1.04122e-14
cg43306_16 xdut.xana.xsup.xref.xiconst.net226 0 c=9.52733e-15
c43306_15 xdut.xana.xsup.xref.xiconst.net226 xdut.xana.xsup.xref.xiconst.vbn c=5.71884e-15
c43306_10 xdut.xana.xsup.xref.xiconst.net226 xdut.xana.xsup.xref.xiconst.a1 c=1.07293e-15
c43306_3 xdut.xana.xsup.xref.xiconst.net226 xdut.xana.xsup.xref.xiconst.net274 c=1.22048e-15
c43306_2 xdut.xana.xsup.xref.xiconst.net226 xdut.xana.xsup.xref.xiconst.net233 c=3.85965e-15
cg43305_11 xdut.xana.xsup.xref.xiconst.vbn 0 c=1.34294e-14
c43305_4 xdut.xana.xsup.xref.xiconst.vbn xdut.xana.xsup.xref.xiconst.net274 c=3.24584e-15
c43305_2 xdut.xana.xsup.xref.xiconst.vbn xdut.xana.xsup.xref.xiconst.net245 c=1.69572e-15
c43304_4 xdut.xana.ln_sup.ref.iconst.n_603 xdut.xana.ln_sup.ref.iconst.n_602 c=2.77489e-15
c43304_3 xdut.xana.ln_sup.ref.iconst.n_603 xdut.xana.ln_sup.ref.iconst.n_601 c=2.78451e-15
c43303_1 xdut.xana.ln_sup.ref.iconst.n_602 xdut.xana.ln_sup.ref.iconst.n_590 c=2.86741e-15
c43302_2 xdut.xana.ln_sup.ref.iconst.n_601 xdut.xana.ln_sup.ref.iconst.n_600 c=2.77905e-15
c43301_2 xdut.xana.ln_sup.ref.iconst.n_600 xdut.xana.ln_sup.ref.iconst.n_599 c=2.75536e-15
c43300_2 xdut.xana.ln_sup.ref.iconst.n_599 xdut.xana.ln_sup.ref.iconst.n_598 c=2.78535e-15
c43299_1 xdut.xana.ln_sup.ref.iconst.n_598 xdut.xana.ln_sup.ref.iconst.n_596 c=2.77183e-15
c43298_3 xdut.xana.ln_sup.ref.iconst.n_597 xdut.xana.ln_sup.ref.iconst.n_596 c=2.75976e-15
c43298_1 xdut.xana.ln_sup.ref.iconst.n_597 xdut.xana.ln_sup.ref.iconst.n_594 c=2.78027e-15
c43296_4 xdut.xana.ln_sup.ref.iconst.n_595 xdut.xana.ln_sup.ref.iconst.n_594 c=2.77556e-15
c43296_3 xdut.xana.ln_sup.ref.iconst.n_595 xdut.xana.ln_sup.ref.iconst.n_593 c=2.76475e-15
c43294_2 xdut.xana.ln_sup.ref.iconst.n_593 xdut.xana.ln_sup.ref.iconst.n_592 c=2.77893e-15
c43293_3 xdut.xana.ln_sup.ref.iconst.n_592 xdut.xana.ln_sup.ref.iconst.n_591 c=2.77855e-15
c43292_2 xdut.xana.ln_sup.ref.iconst.n_591 xdut.xana.xsup.xref.xiconst.vbuf c=2.83126e-15
cg43290_20 xdut.xana.xsup.xref.xiconst.a2 0 c=9.88667e-15
c43290_19 xdut.xana.xsup.xref.xiconst.a2 xdut.xana.xsup.xref.xiconst.net251 c=6.20833e-15
c43290_18 xdut.xana.xsup.xref.xiconst.a2 xdut.xana.xsup.xref.xiconst.net258 c=1.01287e-14
c43290_16 xdut.xana.xsup.xref.xiconst.a2 xdut.xana.xsup.xref.xiconst.tr3n c=2.29792e-15
c43290_15 xdut.xana.xsup.xref.xiconst.a2 xdut.xana.xsup.xref.xiconst.tr0 c=3.17883e-15
c43290_14 xdut.xana.xsup.xref.xiconst.a2 xdut.xana.xsup.xref.xiconst.tr1 c=1.94953e-15
c43290_13 xdut.xana.xsup.xref.xiconst.a2 xdut.xana.xsup.xref.xiconst.tr2 c=1.58966e-15
c43290_9 xdut.xana.xsup.xref.xiconst.a2 xdut.xana.xsup.xref.xiconst.net233 c=8.31443e-15
c43290_8 xdut.xana.xsup.xref.xiconst.a2 xdut.xana.xsup.xref.xiconst.net244 c=9.18296e-15
c43290_5 xdut.xana.xsup.xref.xiconst.a2 xdut.xana.ic5u<7> c=3.08956e-15
c43290_4 xdut.xana.xsup.xref.xiconst.a2 xdut.xana.ic5u<2> c=3.19347e-15
cg43289_13 xdut.xana.xsup.xref.xiconst.net251 0 c=2.50941e-15
c43289_6 xdut.xana.xsup.xref.xiconst.net251 xdut.xana.xsup.xref.xiconst.net252 c=4.72836e-15
c43289_1 xdut.xana.xsup.xref.xiconst.net251 xdut.xana.xsup.xref.xiconst.net245 c=1.71995e-15
cg43288_12 xdut.xana.xsup.xref.xiconst.net258 0 c=2.75562e-15
c43288_6 xdut.xana.xsup.xref.xiconst.net258 xdut.xana.xsup.xref.xiconst.net252 c=1.04126e-15
c43288_5 xdut.xana.xsup.xref.xiconst.net258 xdut.xana.xsup.xref.xiconst.net259 c=1.61024e-15
cg43287_6 xdut.xana.xsup.xref.xiconst.ic9u<3> 0 c=2.29957e-15
c43287_2 xdut.xana.xsup.xref.xiconst.ic9u<3> xdut.xana.xsup.xref.xiconst.a1 c=1.00372e-15
cg43286_6 xdut.xana.xsup.xref.xiconst.ic9u<2> 0 c=1.94711e-15
cg43285_4 xdut.xana.xsup.xref.xiconst.ic9u<1> 0 c=3.01646e-15
cg43284_3 xdut.xana.xsup.xref.xiconst.ic9u<0> 0 c=3.43626e-15
cg43283_18 xdut.xana.xsup.xref.xiconst.irpo5u 0 c=9.60987e-15
c43283_17 xdut.xana.xsup.xref.xiconst.irpo5u xdut.xana.xsup.xref.xiconst.a1 c=7.46593e-15
cg43280_7 xdut.xana.xsup.xref.xiconst.a1 0 c=1.11907e-14
c43280_6 xdut.xana.xsup.xref.xiconst.a1 xdut.xana.xsup.xref.xiconst.gate c=6.82991e-15
cg43279_11 xdut.xana.xsup.xref.xiconst.tr3n 0 c=1.1524e-15
c43279_7 xdut.xana.xsup.xref.xiconst.tr3n xdut.xana.xsup.xref.xiconst.tr2 c=8.24389e-15
c43279_4 xdut.xana.xsup.xref.xiconst.tr3n xdut.xana.xsup.xref.xiconst.net233 c=1.33007e-15
c43279_3 xdut.xana.xsup.xref.xiconst.tr3n xdut.xana.xsup.xref.xiconst.net244 c=2.66208e-15
cg43278_6 xdut.xana.xsup.xref.xiconst.gate 0 c=7.50519e-15
c43278_5 xdut.xana.xsup.xref.xiconst.gate xdut.xana.xsup.xref.xiconst.vbuf c=6.7992e-15
c43278_1 xdut.xana.xsup.xref.xiconst.gate xdut.xana.xsup.xref.iaux10u c=1.46173e-15
c43276_5 xdut.xana.xsup.xref.xiconst.tr0 xdut.xana.xsup.xref.xiconst.tr1 c=6.61529e-15
c43274_7 xdut.xana.xsup.xref.xiconst.tr1 xdut.xana.xsup.xref.xiconst.tr2 c=4.27563e-15
cg43272_4 xdut.xana.xsup.xref.xiconst.vbuf 0 c=1.04005e-14
cg43271_7 xdut.xana.xsup.xref.xiconst.tr2 0 c=1.03186e-15
c43271_4 xdut.xana.xsup.xref.xiconst.tr2 xdut.xana.xsup.xref.xiconst.net244 c=1.21125e-15
cg43270_4 xdut.xana.xsup.xref.xiconst.net252 0 c=2.64186e-15
c43270_3 xdut.xana.xsup.xref.xiconst.net252 xdut.xana.xsup.xref.xiconst.net259 c=4.91912e-15
c43270_2 xdut.xana.xsup.xref.xiconst.net252 xdut.xana.xsup.xref.xiconst.net274 c=1.40392e-15
cg43268_6 xdut.xana.xsup.xref.xiconst.net259 0 c=3.62054e-15
c43268_5 xdut.xana.xsup.xref.xiconst.net259 xdut.xana.xsup.xref.xiconst.net274 c=6.82887e-15
c43268_4 xdut.xana.xsup.xref.xiconst.net259 xdut.xana.xsup.xref.xiconst.net245 c=6.98032e-15
cg43266_5 xdut.xana.xsup.xref.xiconst.net274 0 c=2.52443e-15
cg43265_3 xdut.xana.xsup.xref.xiconst.net233 0 c=3.45339e-15
c43265_2 xdut.xana.xsup.xref.xiconst.net233 xdut.xana.xsup.xref.xiconst.net244 c=3.01075e-15
cg43264_2 xdut.xana.xsup.xref.xiconst.net244 0 c=2.24821e-15
cg43263_1 xdut.xana.xsup.xref.xiconst.net245 0 c=3.69109e-15
cg43206_4 xdut.xana.xsup.xref.xbg.xi109.vref<7> 0 c=3.05943e-15
c43206_1 xdut.xana.xsup.xref.xbg.xi109.vref<7> xdut.xana.xsup.xref.vref_iconst c=1.67802e-15
cg43198_6 xdut.xana.xsup.xref.xbg.xi109.vref<9> 0 c=9.07056e-15
c43198_1 xdut.xana.xsup.xref.xbg.xi109.vref<9> xdut.xana.xsup.xref.vref_iconst c=1.36031e-14
cg43196_13 xdut.xana.xsup.xref.xbg.net440 0 c=8.54771e-15
c43196_12 xdut.xana.xsup.xref.xbg.net440 xdut.xana.xsup.xref.xbg.net539 c=1.87042e-14
c43196_10 xdut.xana.xsup.xref.xbg.net440 xdut.xana.xsup.xref.xbg.b c=1.30295e-14
c43196_8 xdut.xana.xsup.xref.xbg.net440 xdut.xana.xsup.xref.xbg.nwell1 c=1.03897e-14
c43196_7 xdut.xana.xsup.xref.xbg.net440 xdut.xana.xsup.xref.xbg.net453 c=2.38488e-15
cg43195_10 xdut.xana.xsup.xref.xbg.net539 0 c=1.52526e-14
c43195_9 xdut.xana.xsup.xref.xbg.net539 xdut.xana.xsup.xref.xbg.net532 c=4.37585e-15
c43195_8 xdut.xana.xsup.xref.xbg.net539 xdut.xana.xsup.xref.xbg.b c=2.72088e-15
c43195_7 xdut.xana.xsup.xref.xbg.net539 xdut.xana.xsup.xref.xbg.nwell1 c=2.01403e-14
cg43194_14 xdut.xana.xsup.xref.xbg.net532 0 c=1.10917e-14
c43194_13 xdut.xana.xsup.xref.xbg.net532 xdut.xana.xsup.xref.xbg.b c=1.70112e-14
c43194_12 xdut.xana.xsup.xref.xbg.net532 xdut.xana.xsup.xref.xbg.vbp_ibias c=1.74111e-14
c43194_11 xdut.xana.xsup.xref.xbg.net532 xdut.xana.xsup.xref.xbg.nwell1 c=2.9941e-15
c43194_10 xdut.xana.xsup.xref.xbg.net532 xdut.xana.xsup.xref.xbg.net427 c=1.82344e-15
c43194_9 xdut.xana.xsup.xref.xbg.net532 xdut.xana.xsup.ibp10u<0> c=1.03739e-15
cg43193_12 xdut.xana.xsup.xref.xbg.b 0 c=1.74737e-14
c43193_10 xdut.xana.xsup.xref.xbg.b xdut.xana.xsup.xref.xbg.nwell1 c=6.93189e-15
c43193_8 xdut.xana.xsup.xref.xbg.b xdut.xana.xsup.xref.xbg.net427 c=1.01763e-15
c43193_7 xdut.xana.xsup.xref.xbg.b xdut.xana.xsup.xref.xbg.a c=1.56531e-12
c43193_4 xdut.xana.xsup.xref.xbg.b xdut.xana.xsup.xref.xbg.rs_nwell c=4.16188e-15
cg43192_12 xdut.xana.xsup.xref.xbg.vbp_ibias 0 c=1.28123e-14
c43192_11 xdut.xana.xsup.xref.xbg.vbp_ibias xdut.xana.xsup.xref.xbg.nwell1 c=1.43197e-15
c43192_10 xdut.xana.xsup.xref.xbg.vbp_ibias xdut.xana.xsup.xref.xbg.net427 c=6.0214e-15
c43192_9 xdut.xana.xsup.xref.xbg.vbp_ibias xdut.xana.xsup.ibp10u<0> c=3.46122e-15
c43192_4 xdut.xana.xsup.xref.xbg.vbp_ibias xdut.xana.xsup.ibp10u<3> c=2.49276e-15
c43192_3 xdut.xana.xsup.xref.xbg.vbp_ibias xdut.xana.xsup.xref.iaux10u c=2.46145e-15
c43192_2 xdut.xana.xsup.xref.xbg.vbp_ibias xdut.xana.xsup.ibp5u<1> c=1.21087e-15
c43192_1 xdut.xana.xsup.xref.xbg.vbp_ibias xdut.xana.xsup.ibp10u<1> c=2.40323e-15
cg43191_8 xdut.xana.xsup.xref.xbg.nwell1 0 c=2.48281e-14
c43191_5 xdut.xana.xsup.xref.xbg.nwell1 xdut.xana.xsup.xref.xbg.rs_nwell c=1.11768e-14
cg43190_6 xdut.xana.xsup.xref.xbg.net453 0 c=2.1952e-14
c43190_5 xdut.xana.xsup.xref.xbg.net453 xdut.xana.xsup.xref.xbg.a c=2.6307e-14
c43190_4 xdut.xana.xsup.xref.xbg.net453 xdut.xana.xsup.xref.xbg.net497 c=6.30181e-15
c43190_3 xdut.xana.xsup.xref.xbg.net453 xdut.xana.xsup.xref.xbg.net496 c=1.35014e-15
cg43189_3 xdut.xana.xsup.xref.xbg.net427 0 c=2.45621e-15
cg43186_4 xdut.xana.xsup.xref.xbg.a 0 c=1.5952e-13
c43186_3 xdut.xana.xsup.xref.xbg.a xdut.xana.xsup.xref.xbg.net497 c=1.38141e-14
c43186_2 xdut.xana.xsup.xref.xbg.a xdut.xana.xsup.xref.xbg.net496 c=3.81912e-14
c43186_1 xdut.xana.xsup.xref.xbg.a xdut.xana.xsup.xref.xbg.rs_nwell c=2.43483e-15
cg43182_4 xdut.xana.xsup.xref.xbg.net497 0 c=9.03372e-15
c43182_3 xdut.xana.xsup.xref.xbg.net497 xdut.xana.xsup.xref.xbg.net496 c=2.79723e-14
c43182_2 xdut.xana.xsup.xref.xbg.net497 xdut.xana.xsup.xref.xbg.rs_nwell c=1.01978e-15
cg43181_3 xdut.xana.xsup.xref.xbg.net496 0 c=3.88376e-14
c43181_2 xdut.xana.xsup.xref.xbg.net496 xdut.xana.xsup.xref.xbg.rs_nwell c=2.96902e-15
cg43180_2 xdut.xana.xsup.xref.xbg.rs_nwell 0 c=6.83548e-14
c43180_1 xdut.xana.xsup.xref.xbg.rs_nwell xdut.xana.xsup.xref.vref_iconst c=2.07894e-15
cg43179_9 xdut.xana.xsup.ibp10u<0> 0 c=5.05895e-15
c43179_1 xdut.xana.xsup.ibp10u<0> xdut.xana.xsup.ibp10u<1> c=1.90239e-14
cg43177_12 xdut.xana.xsup.xref.ibp1u<3> 0 c=1.00167e-14
c43177_11 xdut.xana.xsup.xref.ibp1u<3> xdut.xana.xsup.xref.ibp1u<2> c=1.31062e-15
cg43176_9 xdut.xana.xsup.xref.ibp1u<2> 0 c=9.863e-15
c43176_8 xdut.xana.xsup.xref.ibp1u<2> xdut.xana.xsup.xref.ibp1u<1> c=1.21272e-15
cg43175_7 xdut.xana.xsup.xref.ibp1u<1> 0 c=1.03772e-14
c43175_6 xdut.xana.xsup.xref.ibp1u<1> xdut.xana.xsup.xref.ibp1u<0> c=1.68666e-15
cg43174_7 xdut.xana.xsup.xref.ibp1u<0> 0 c=7.06876e-15
c43174_2 xdut.xana.xsup.xref.ibp1u<0> xdut.xana.xsup.ic5u<12> c=1.35244e-15
cg43173_3 xdut.xana.xsup.xref.vref_iconst 0 c=1.96629e-14
c43173_2 xdut.xana.xsup.xref.vref_iconst xdut.xana.xsup.xref.iaux10u c=1.66111e-14
c43161_4 xdut.xana.xsup.xmux.xsw1.net28 xdut.xana.xsup.xmux.vbg_int c=1.18604e-15
c43161_2 xdut.xana.xsup.xmux.xsw1.net28 xdut.xana.xsup.xmux.xsw1.enb_int c=1.41073e-15
c43160_2 xdut.xana.xsup.xmux.xsw2.net28 xdut.xana.xsup.xmux.xsw2.enb_int c=1.41056e-15
c43158_4 xdut.xana.xsup.xmux.xsw2.en_int xdut.xana.xsup.xmux.xsw2.enb_int c=1.0645e-15
c43156_5 xdut.xana.xsup.xmux.xsw3.en_int xdut.xana.xsup.xmux.xsw3.enb_int c=1.06223e-15
c43155_3 xdut.xana.xsup.xmux.xsw3.enb_int xdut.xana.xsup.xmux.xsw3.net28 c=1.40997e-15
c43154_4 xdut.xana.xsup.xmux.xsw4.en_int xdut.xana.xsup.xmux.xsw4.enb_int c=1.1134e-15
c43153_4 xdut.xana.xsup.xmux.xsw4.enb_int xdut.xana.xsup.xmux.xsw4.net28 c=1.41826e-15
c43152_2 xdut.xana.xsup.xmux.xsw1.en_int xdut.xana.xsup.xmux.xsw1.enb_int c=1.06218e-15
c43150_2 xdut.xana.xsup.xmux.xsw3.net28 xdut.xana.xsup.ic5u<12> c=1.17767e-15
c43149_3 xdut.xana.xsup.xmux.xsw4.net28 xdut.xana.xsup.ibp10u<3> c=1.20798e-15
c43065_3 xdut.xana.xsup.xls3<4>.ls_an xdut.xana.xsup.xls3<4>.ls_a c=1.58178e-15
cg43061_17 xdut.xana.xsup.atst_sup_5v<4> 0 c=8.05186e-15
c43061_5 xdut.xana.xsup.atst_sup_5v<4> xdut.xana.xsup.xvrrmon.net42 c=3.53297e-15
c43061_1 xdut.xana.xsup.atst_sup_5v<4> xdut.xana.xsup.vrr_ok_5v c=1.21391e-14
c43058_1 xdut.xana.xsup.xls7<0>.ls_an xdut.xana.xsup.xls7<0>.ls_a c=1.58238e-15
cg43055_25 xdut.xana.xsup.i_trim_5v<0> 0 c=7.21831e-15
c43055_24 xdut.xana.xsup.i_trim_5v<0> xdut.xana.xsup.i_trim_5v<1> c=1.30928e-14
cg43054_19 xdut.xana.xsup.i_trim_5v<1> 0 c=3.78586e-15
c43054_15 xdut.xana.xsup.i_trim_5v<1> xdut.xana.xsup.i_trim_5v<2> c=1.13468e-14
c43051_1 xdut.xana.xsup.xls7<1>.ls_an xdut.xana.xsup.xls7<1>.ls_a c=1.58467e-15
cg43048_6 xdut.xana.xsup.ibp10u<3> 0 c=5.76922e-15
c43048_5 xdut.xana.xsup.ibp10u<3> xdut.xana.xsup.xref.iaux10u c=2.00602e-14
c43048_3 xdut.xana.xsup.ibp10u<3> xdut.xana.xsup.ibp10u<1> c=1.46723e-15
cg43047_4 xdut.xana.xsup.xref.iaux10u 0 c=1.1995e-14
c43047_3 xdut.xana.xsup.xref.iaux10u xdut.xana.xsup.ibp5u<1> c=1.12867e-15
cg43045_13 xdut.xana.xsup.i_trim_5v<2> 0 c=3.62439e-15
c43045_10 xdut.xana.xsup.i_trim_5v<2> xdut.xana.xsup.i_trim_5v<3> c=8.7299e-15
cg43044_5 xdut.xana.xsup.ibp5u<1> 0 c=7.48344e-15
c43038_1 xdut.xana.xsup.xls7<2>.ls_an xdut.xana.xsup.xls7<2>.ls_a c=1.58594e-15
cg43036_11 xdut.xana.xsup.ic5u<12> 0 c=1.42293e-14
c43036_1 xdut.xana.xsup.ic5u<12> xdut.xana.ic5u<11> c=1.76568e-15
c43033_1 xdut.xana.xsup.xls7<3>.ls_an xdut.xana.xsup.xls7<3>.ls_a c=1.58459e-15
cg43027_10 xdut.xana.xsup.i_trim_5v<3> 0 c=3.38426e-15
cg43026_7 xdut.xana.xsup.xvrrmon.vrr_uv_5v 0 c=5.31498e-15
c43026_6 xdut.xana.xsup.xvrrmon.vrr_uv_5v xdut.xana.xsup.xvrrmon.vrr_ov_5v c=8.10407e-15
cg43025_6 xdut.xana.xsup.xvrrmon.vrr_ov_5v 0 c=6.98966e-15
c43025_1 xdut.xana.xsup.xvrrmon.vrr_ov_5v xdut.xana.xsup.vrr_ok_5v c=1.09612e-15
cg43024_3 xdut.xana.xsup.xvbgbuf.vcc_nbl 0 c=2.13241e-14
cg43019_5 xdut.xana.xsup.xvrrmon.net9 0 c=4.39528e-15
c43019_4 xdut.xana.xsup.xvrrmon.net9 xdut.xana.xsup.xvrrmon.net5 c=5.48043e-15
cg43018_4 xdut.xana.xsup.xvrrmon.net5 0 c=2.71242e-15
cg43017_3 xdut.xana.xsup.ibp10u<1> 0 c=7.41796e-15
c43017_1 xdut.xana.xsup.ibp10u<1> xdut.xana.xsup.vrr_ok_5v c=1.16414e-15
c43012_4 xdut.xana.xsup.xls3<0>.ls_a xdut.xana.xsup.xls3<0>.ls_an c=1.59514e-15
c43011_3 xdut.xana.xsup.xls3<1>.ls_a xdut.xana.xsup.xls3<1>.ls_an c=1.5821e-15
c43009_3 xdut.xana.xsup.xls3<2>.ls_a xdut.xana.xsup.xls3<2>.ls_an c=1.58249e-15
c43005_3 xdut.xana.xsup.xls3<3>.ls_a xdut.xana.xsup.xls3<3>.ls_an c=1.59083e-15
cg42988_3 xdut.xana.xsup.atst_sup_5v<0> 0 c=2.11681e-15
c42988_2 xdut.xana.xsup.atst_sup_5v<0> xdut.xana.xsup.atst_sup_5v<1> c=9.23155e-15
cg42987_6 xdut.xana.xsup.atst_sup_5v<1> 0 c=1.47611e-15
c42987_2 xdut.xana.xsup.atst_sup_5v<1> xdut.xana.xsup.atst_sup_5v<2> c=9.15706e-15
cg42980_4 xdut.xana.xsup.atst_sup_5v<2> 0 c=1.58686e-15
c42980_1 xdut.xana.xsup.atst_sup_5v<2> xdut.xana.xsup.atst_sup_5v<3> c=8.87029e-15
cg42971_1 xdut.xana.xsup.atst_sup_5v<3> 0 c=2.10326e-15
cg42968_4 xdut.xana.irp10u<3> 0 c=2.10391e-15
c42968_3 xdut.xana.irp10u<3> xdut.xana.irp10u<2> c=1.95754e-15
c42968_2 xdut.xana.irp10u<3> xdut.xana.ic5u<7> c=4.61801e-15
cg42967_5 xdut.xana.irp10u<2> 0 c=2.16698e-15
c42967_3 xdut.xana.irp10u<2> xdut.xana.ic5u<2> c=5.1919e-15
cg42966_5 xdut.xana.ic5u<7> 0 c=2.28451e-15
c42966_3 xdut.xana.ic5u<7> xdut.xana.ic5u<3> c=4.83085e-15
cg42965_3 xdut.xana.ic5u<2> 0 c=1.44357e-15
c42965_1 xdut.xana.ic5u<2> xdut.xana.ic5u<6> c=1.04374e-14
cg42964_3 xdut.xana.ic5u<3> 0 c=1.71317e-15
cg42963_2 xdut.xana.ic5u<6> 0 c=2.44618e-15
cg769_2 xdut.xana.xsup.vrr_ok_5v 0 c=7.58509e-15
cg764_1 xdut.xana.ic5u<11> 0 c=3.86614e-15
c699_5 xdut.xpad2.ds_ls xdut.xpad2.gnstrong c=1.44825e-15
c698_3 xdut.xpad2.dsb_ls xdut.xpad2.gpstrong c=1.14349e-15
c697_4 xdut.xpad2.xlsds.o1b xdut.xpad2.xlsds.o1 c=1.51305e-15
c695_10 xdut.xpad2.gp xdut.xpad2.xlsgp.o1b c=1.50344e-15
c695_1 xdut.xpad2.gp xdut.xpad2.gpweak c=1.49917e-15
c693_1 xdut.xpad2.xlsgp.o1b xdut.xpad2.xlsgp.o1 c=1.44602e-15
c692_5 xdut.xpad2.xlsgn.o1b xdut.xpad2.xlsgn.o1 c=1.44913e-15
c688_1 xdut.xpad2.gn xdut.xpad2.gnweak c=1.46289e-15
c687_4 xdut.xpad2.gnstrong xdut.xpad2.gnweak c=1.60373e-15
c687_1 xdut.xpad2.gnstrong xdut.tmode_p c=6.12302e-15
c686_3 xdut.xpad2.gnweak xdut.xpad2.gpweak c=7.4692e-15
c686_1 xdut.xpad2.gnweak xdut.tmode_p c=2.35233e-15
c685_2 xdut.xpad2.gpstrong xdut.xpad2.gpweak c=2.80438e-15
c685_1 xdut.xpad2.gpstrong xdut.tmode_p c=1.98099e-14
c684_1 xdut.xpad2.gpweak xdut.tmode_p c=7.44761e-15
c620_11 xdut.xpad1.gp xdut.xpad1.xlsgp.o1b c=1.50344e-15
c618_1 xdut.xpad1.xlsgp.o1b xdut.xpad1.xlsgp.o1 c=1.44602e-15
c617_2 xdut.xpad1.ds_ls xdut.xpad1.gnstrong c=1.44825e-15
c616_2 xdut.xpad1.dsb_ls xdut.xpad1.gpstrong c=1.14349e-15
c615_2 xdut.xpad1.xlsds.o1b xdut.xpad1.xlsds.o1 c=1.51305e-15
c611_2 xdut.xpad1.xlsgn.o1b xdut.xpad1.xlsgn.o1 c=1.44913e-15
c604_13 xdut.net2140 xdut.xpad2.aoutb c=1.35172e-15
c604_7 xdut.net2140 xdut.xpad2.pd_ls c=1.6112e-15
c604_4 xdut.net2140 xdut.xpad2.net424 c=2.10182e-15
c602_7 xdut.xpad2.aoutb xdut.xpad2.aoutbb c=1.26467e-15
c602_3 xdut.xpad2.aoutb xdut.xpad2.ie_ls c=1.79858e-15
c601_6 xdut.xpad2.aoutbb xdut.xpad2.ie_ls c=2.06067e-15
c598_6 xdut.xpad2.xlspu.o1b xdut.xpad2.xlspu.o1 c=1.45527e-15
c594_5 xdut.xpad2.xlspd.o1b xdut.xpad2.xlspd.o1 c=1.45401e-15
c589_1 xdut.xpad2.xlsie.o1b xdut.xpad2.xlsie.o1 c=1.4749e-15
cg411_2 xdut.net3135 0 c=3.50439e-15
c411_1 xdut.net3135 xdut.tmode_p c=2.99803e-15
cg22_1 xdut.tmode_p 0 c=6.91276e-14
cg41559_4 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.vdiv 0 c=1.98143e-15
cg41523_23 xdut.xana.xdsi_ch1<1>.xtx.xtx_amp_fb_0.inn_5v 0 c=3.49819e-15
c41515_3 xdut.xana.xdsi_ch1<1>.xtx.tx_data_5v<4> xdut.dsi_tx_data<8> c=1.0324e-15
c41512_4 xdut.xana.xdsi_ch1<1>.xtx.tx_data_5v<3> xdut.dsi_tx_data<7> c=1.01461e-15
c41507_1 xdut.xana.xdsi_ch1<1>.xtx.tx_data_5v<2> xdut.dsi_tx_data<6> c=1.03362e-15
c41506_2 xdut.xana.xdsi_ch1<1>.xtx.tx_data_5v<1> xdut.dsi_tx_data<5> c=1.04503e-15
c41466_5 xdut.xana.xdsi_ch1<1>.xtx.tx_data_5v<0> xdut.atst_tx<13> c=1.03471e-15
c41430_4 xdut.xana.xdsi_ch1<1>.xtx.net934 xdut.xana.xdsi_ch1<1>.xtx.net933 c=1.04138e-15
c41428_3 xdut.xana.xdsi_ch1<1>.xtx.idac_5v<2> xdut.xana.xdsi_ch1<1>.xtx.net935 c=1.12411e-15
c41357_1 xdut.xana.xdsi_ch1<1>.xtx.xtx_lvl_out_ov.net130 xdut.dsi_ov<1> c=1.00908e-15
cg41149_12 xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.nd4 0 c=1.13591e-15
cg41137_8 xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.idac2atb_5v_b 0 c=1.16189e-14
cg41133_7 xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.nd0 0 c=1.14982e-15
cg41130_6 xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.nd1 0 c=1.624e-15
cg41115_9 xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.on_os_3 0 c=4.04149e-15
cg41114_9 xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.on_osb_3 0 c=3.97819e-15
cg41113_8 xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.on_os_3 0 c=4.03559e-15
cg41112_7 xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.on_osb_3 0 c=3.96583e-15
cg41090_3 xdut.xana.ln_dsi_ch1<1>.rx.ls8.n_60 0 c=2.06788e-15
c41090_2 xdut.xana.ln_dsi_ch1<1>.rx.ls8.n_60 xdut.xana.ln_dsi_ch1<1>.rx.ls8.n_59 c=2.38303e-15
cg41088_3 xdut.xana.xdsi_ch1<1>.xrx.xls8.net106 0 c=6.82404e-15
cg40818_4 xdut.xana.xdsi_ch1<1>.xrx.xdat2_cmp.net462 0 c=1.15548e-15
c40682_5 xdut.xana.xdsi_ch1<1>.xrx.inn_d2cmp xdut.xana.xdsi_ch1<1>.xrx.inp_d2cmp c=3.85777e-14
cg40609_9 xdut.xana.xdsi_ch1<1>.xrx.flt_fast_5v 0 c=6.99705e-15
c40603_2 xdut.xana.xdsi_ch1<1>.xrx.net718 xdut.dsi_rxd2<1> c=1.00667e-15
c40602_1 xdut.xana.xdsi_ch1<1>.xrx.net719 xdut.dsi_rxd1<1> c=1.00954e-15
c40601_1 xdut.xana.xdsi_ch1<1>.xrx.net880 xdut.dsi_icmp<1> c=1.00605e-15
cg40568_2 xdut.xana.xdsi_ch1<1>.xrx.xls8.net107 0 c=1.91408e-15
cg21694_4 xdut.xana.xdsi_ch1<1>.xrx.xrec_th.dat2_sw_d 0 c=1.75706e-15
cg21693_2 xdut.xana.xdsi_ch1<1>.xrx.xrec_th.dat1_sw_d 0 c=1.95853e-15
cg21692_1 xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim2.idat_os_summe 0 c=2.68065e-15
cg21691_1 xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xtrim1.idat_os_summe 0 c=2.83803e-15
cg504_2 xdut.trim_dsi_rx2<4> 0 c=1.69092e-15
cg502_1 xdut.trim_dsi_rx2<5> 0 c=2.07185e-15
cg501_1 xdut.trim_dsi_rx2<6> 0 c=2.04448e-15
cg500_1 xdut.trim_dsi_rx1<5> 0 c=2.07384e-15
cg499_1 xdut.trim_dsi_rx1<4> 0 c=2.08634e-15
cg498_1 xdut.trim_dsi_rx2<7> 0 c=2.02075e-15
cg497_1 xdut.trim_dsi_rx1<6> 0 c=1.99415e-15
cg496_1 xdut.dsi_rx_on<1> 0 c=1.90352e-15
cg495_1 xdut.trim_dsi_rx1<7> 0 c=2.20221e-15
cg378_1 xdut.dsi_rxd2<1> 0 c=2.24364e-15
cg377_2 xdut.dsi_rx_filter_fast<1> 0 c=1.20533e-15
cg376_1 xdut.dsi_rxd1<1> 0 c=2.02024e-15
c375_9 xdut.dsi_tx_tbit_cfg<3> xdut.atst_tx<13> c=1.04274e-14
c375_5 xdut.dsi_tx_tbit_cfg<3> xdut.dsi_tx_tbit_cfg<2> c=1.14285e-14
c374_2 xdut.atst_tx<13> xdut.dsi_tx_data<5> c=9.321e-15
cg373_8 xdut.dsi_ov<1> 0 c=1.81469e-15
c373_7 xdut.dsi_ov<1> xdut.dsi_rx_txn<1> c=2.29013e-15
c372_5 xdut.dsi_rx_txn<1> xdut.dsi_tx_tbit_cfg<2> c=1.26929e-14
cg371_6 xdut.dsi_tx_data<9> 0 c=1.40169e-15
c371_3 xdut.dsi_tx_data<9> xdut.dsi_tx_data<8> c=5.25525e-15
cg364_1 xdut.dsi_icmp<1> 0 c=2.19175e-15
c321_3 xdut.dsi_tx_data<7> xdut.dsi_tx_data<8> c=6.27771e-15
c321_1 xdut.dsi_tx_data<7> xdut.dsi_tx_data<6> c=7.32947e-15
c319_1 xdut.dsi_tx_data<5> xdut.dsi_tx_data<6> c=8.38067e-15
cg230_1 xdut.xana.xdsi_ch1<1>.xrx.xrec_th.offs_sw_d 0 c=2.14167e-15
cg229_1 xdut.xana.xdsi_ch1<1>.xrx.xrec_th.xidac.isum 0 c=3.84619e-15
cg20656_4 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.vdiv 0 c=1.93379e-15
cg20629_32 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vbn_5v 0 c=9.7794e-15
cg20620_26 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.inn_5v 0 c=3.36016e-15
cg20594_40 xdut.xana.xdsi_ch1<0>.xtx.xi44.xu42-net12 0 c=1.02993e-15
cg20570_18 xdut.xana.xdsi_ch1<0>.xtx.xtx_amp_fb_0.xtx_amp_ab_0.vncin2 0 c=3.07607e-15
c20527_4 xdut.xana.xdsi_ch1<0>.xtx.net934 xdut.xana.xdsi_ch1<0>.xtx.net933 c=1.04165e-15
c20525_3 xdut.xana.xdsi_ch1<0>.xtx.idac_5v<2> xdut.xana.xdsi_ch1<0>.xtx.net935 c=1.10893e-15
cg20211_7 xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim1.on_osb_3 0 c=3.99557e-15
cg20209_6 xdut.xana.xdsi_ch1<0>.xrx.xrec_th.xtrim2.on_osb_3 0 c=3.9917e-15
cg20187_3 xdut.xana.ln_dsi_ch1<0>.rx.ls8.n_60 0 c=2.06788e-15
c20187_2 xdut.xana.ln_dsi_ch1<0>.rx.ls8.n_60 xdut.xana.ln_dsi_ch1<0>.rx.ls8.n_59 c=2.38303e-15
cg20185_3 xdut.xana.xdsi_ch1<0>.xrx.xls8.net106 0 c=6.90504e-15
cg19915_3 xdut.xana.xdsi_ch1<0>.xrx.xdat2_cmp.net462 0 c=1.23373e-15
cg19706_7 xdut.xana.xdsi_ch1<0>.xrx.flt_fast_5v 0 c=7.0056e-15
cg19665_2 xdut.xana.xdsi_ch1<0>.xrx.xls8.net107 0 c=1.86295e-15
cg791_2 xdut.xana.xdsi_ch1<0>.xrx.xrec_th.dat2_sw_d 0 c=1.80835e-15
cg790_1 xdut.xana.xdsi_ch1<0>.xrx.xrec_th.dat1_sw_d 0 c=1.96886e-15
cg759_3 xdut.xana.net875 0 c=5.12935e-15
cg647705_15 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.vtailn 0 c=1.38459e-15
cg647678_28 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net1531 0 c=2.04013e-14
cg647674_14 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.stdby 0 c=3.10999e-15
cg647642_4 xdut.xosc.xpll_top_0.xpll_core_0.xvi_0.net229 0 c=3.51194e-15
cg647640_5 xdut.xosc.xpll_top_0.xpll_core_0.xvi_0.net172 0 c=8.77248e-15
cg647555_5 xdut.xosc.xpll_top_0.xpll_core_0.xlpf_0.net28 0 c=1.64791e-14
cg647526_32 xdut.xosc.xpll_top_0.xpll_core_0.xdiv36_0.xclk_div<32>0.net559 0 c=1.23613e-15
cg647446_66 xdut.xosc.xpll_top_0.xpll_core_0.xdiv36_0.xclk_div<32>0.cmp 0 c=1.95855e-15
cg647377_26 xdut.xosc.xpll_top_0.xpll_core_0.xdiv36_0.xclk_div<32>0.q<2> 0 c=1.12902e-15
cg647371_26 xdut.xosc.xpll_top_0.xpll_core_0.xdiv36_0.xclk_div<32>0.q<3> 0 c=1.1399e-15
cg647365_25 xdut.xosc.xpll_top_0.xpll_core_0.xdiv36_0.xclk_div<32>0.q<4> 0 c=1.00013e-15
cg647295_18 xdut.xosc.xpll_top_0.xpll_core_0.downz 0 c=1.52486e-15
cg647294_11 xdut.xosc.xpll_top_0.xpll_core_0.downqz 0 c=1.30386e-15
cg647285_19 xdut.xosc.xpll_top_0.xpll_core_0.upqz 0 c=1.23248e-15
cg647264_14 xdut.xosc.xpll_top_0.xpll_core_0.upz 0 c=1.515e-15
cg647257_18 xdut.xosc.xpll_top_0.xpll_core_0.up 0 c=2.14e-15
cg647254_12 xdut.xosc.xpll_top_0.xpll_core_0.pd_int 0 c=6.20319e-15
cg647252_31 xdut.xosc.xpll_top_0.xpll_core_0.pd_n 0 c=1.0456e-14
cg647248_7 xdut.xosc.xpll_top_0.xpll_core_0.hiz 0 c=3.22611e-15
cg647246_14 xdut.xosc.xpll_top_0.xpll_core_0.vlo 0 c=4.2886e-15
cg647233_6 xdut.xosc.xpll_top_0.xpll_core_0.vtune 0 c=1.14718e-14
cg647213_22 xdut.xosc.xpll_top_0.xpll_core_0.xdiv36_0.vh 0 c=1.89289e-15
cg647212_16 xdut.xosc.xpll_top_0.xpll_core_0.vctrl 0 c=1.25215e-14
cg647206_19 xdut.xosc.xpll_top_0.xpll_core_0.xdiv36_0.vl 0 c=2.70699e-15
cg647051_6 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net69<5>@2 0 c=1.82011e-15
cg647050_5 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net69<7>@2 0 c=1.7349e-15
cg647049_5 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net70<4> 0 c=1.82525e-15
cg647048_4 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net70<7> 0 c=1.73975e-15
cg647046_6 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net69<2>@2 0 c=1.72817e-15
cg647045_5 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net69<3> 0 c=1.81059e-15
cg647044_6 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net69<4>@2 0 c=1.72899e-15
cg647043_5 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net69<6> 0 c=1.8148e-15
cg647042_5 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net70<2>@2 0 c=1.73093e-15
cg647041_4 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net70<3> 0 c=1.81573e-15
cg647040_5 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net70<5>@2 0 c=1.73392e-15
cg647039_4 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net70<6> 0 c=1.81986e-15
cg647036_7 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net69<1>@2 0 c=1.72665e-15
cg647035_6 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net69<1> 0 c=1.81288e-15
cg647034_6 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net70<0>@2 0 c=1.7311e-15
cg647033_5 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net70<0> 0 c=1.81744e-15
cg647027_7 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net70<1> 0 c=1.72607e-15
cg647026_6 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net70<1>@2 0 c=1.8113e-15
cg647025_7 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net69<0>@2 0 c=1.73038e-15
cg647024_6 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net69<0> 0 c=1.81554e-15
cg647023_6 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net70<4>@2 0 c=1.72779e-15
cg647022_6 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net70<2> 0 c=1.72671e-15
cg647021_5 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net70<7>@2 0 c=1.84194e-15
cg647020_5 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net70<3>@2 0 c=1.81378e-15
cg647019_6 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net69<7> 0 c=1.73186e-15
cg647018_6 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net69<2> 0 c=1.73107e-15
cg647017_5 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net69<5> 0 c=1.84606e-15
cg647016_5 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net69<3>@2 0 c=1.81824e-15
cg647015_6 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net70<6>@2 0 c=1.72685e-15
cg647014_5 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net70<5> 0 c=1.8158e-15
cg647011_6 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net69<4> 0 c=1.73148e-15
cg647010_5 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.net69<6>@2 0 c=1.82009e-15
cg646955_18 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.vtailp 0 c=2.16981e-15
cg646943_7 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.vbiasp 0 c=3.72913e-15
cg646933_4 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.vcascp 0 c=3.7792e-15
cg646912_4 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.s1 0 c=3.02725e-15
cg646901_3 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.s0 0 c=1.59603e-15
cg646900_2 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.s2 0 c=2.80122e-15
cg646897_1 xdut.xosc.xpll_top_0.xpll_core_0.xchp_0.s3 0 c=8.83419e-15
cg645410_7 xdut.xosc.xclkref_lpf_0.vdd_rc 0 c=3.32765e-14
cg645407_4 xdut.xosc.xclkref_lpf_0.net70 0 c=1.34484e-15
cg645402_1 xdut.xosc.xclkref_lpf_0.rci 0 c=1.11079e-15
cg646738_1 xdut.xosc.xosc_20m_0.xosc20m_0.xop_top.net80 0 c=3.26936e-15
cg646707_6 xdut.xosc.xosc_20m_0.xosc20m_0.xcs_top.vbp 0 c=3.47766e-14
cg646523_8 xdut.xosc.xosc_20m_0.xosc20m_0.net400 0 c=5.12638e-15
cg646349_5 xdut.xosc.xosc_20m_0.xosc20m_0.net511 0 c=1.07028e-15
cg645546_5 xdut.xosc.xosc_20m_0.xosc20m_0.inp 0 c=1.55463e-15
cg225_2 xdut.xosc.xosc_20m_0.xosc20m_0.xcs_top.bh 0 c=1.97554e-14
cg224_1 xdut.xosc.xosc_20m_0.xosc20m_0.xcs_top.bl 0 c=1.26496e-15
